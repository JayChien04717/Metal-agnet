# Ansys Electronics Desktop project, version 2021.2
materials:
  silicon: permittivity=11.9
  silicon_eps11p45: permittivity=11.45
  vacuum: permittivity=1
  pec: conductivity=1e+30

design P250g9_control_1810_hfss (HFSS, Eigenmode, model units mm)
geometry:
  lead_a_cin_path = polyline((-0.000740499, 0, 0) (-0.0007925, 0, 0))
  lead_a_cin = polyline((-0.000740499, -5e-06, 0) (-0.000740499, 5e-06, 0))
  lead_a_cin.sweep_along_path(lead_a_cin_path)
  lead_a_sub_cin_path = polyline((-0.000740499, 0, 0) (-0.0007925, 0, 0))
  lead_a_sub_cin = polyline((-0.000740499, -1.1e-05, 0) (-0.000740499, 1.1e-05, 0))
  lead_a_sub_cin.sweep_along_path(lead_a_sub_cin_path)
  lead_b_cin_path = polyline((-0.000639501, 0, 0) (-0.0005275, 0, 0))
  lead_b_cin = polyline((-0.000639501, 5e-06, 0) (-0.000639501, -5e-06, 0))
  lead_b_cin.sweep_along_path(lead_b_cin_path)
  lead_b_sub_cin_path = polyline((-0.000639501, 0, 0) (-0.0005275, 0, 0))
  lead_b_sub_cin = polyline((-0.000639501, 1.1e-05, 0) (-0.000639501, -1.1e-05, 0))
  lead_b_sub_cin.sweep_along_path(lead_b_sub_cin_path)
  lead_a_cp_path = polyline((0, 0.000202001, 0) (0, 0.00015, 0))
  lead_a_cp = polyline((5e-06, 0.000202001, 0) (-5e-06, 0.000202001, 0))
  lead_a_cp.sweep_along_path(lead_a_cp_path)
  lead_a_sub_cp_path = polyline((0, 0.000202001, 0) (0, 0.00015, 0))
  lead_a_sub_cp = polyline((1.1e-05, 0.000202001, 0) (-1.1e-05, 0.000202001, 0))
  lead_a_sub_cp.sweep_along_path(lead_a_sub_cp_path)
  lead_b_cp_path = polyline((0, 0.000302999, 0) (0, 0.000415, 0))
  lead_b_cp = polyline((-5e-06, 0.000302999, 0) (5e-06, 0.000302999, 0))
  lead_b_cp.sweep_along_path(lead_b_cp_path)
  lead_b_sub_cp_path = polyline((0, 0.000302999, 0) (0, 0.000415, 0))
  lead_b_sub_cp = polyline((-1.1e-05, 0.000302999, 0) (1.1e-05, 0.000302999, 0))
  lead_b_sub_cp.sweep_along_path(lead_b_sub_cp_path)
  trace_feed_in_path = polyline((-0.00162, 0, 0) (-0.0007925, 0, 0))
  trace_feed_in = polyline((-0.00162, 5e-06, 0) (-0.00162, -5e-06, 0))
  trace_feed_in.sweep_along_path(trace_feed_in_path)
  cut_feed_in_path = polyline((-0.00162, 0, 0) (-0.0007925, 0, 0))
  cut_feed_in = polyline((-0.00162, 1.1e-05, 0) (-0.00162, -1.1e-05, 0))
  cut_feed_in.sweep_along_path(cut_feed_in_path)
  trace_feed_mid_path = polyline((-0.0005275, 0, 0) (-0.00015, 0, 0))
  trace_feed_mid = polyline((-0.0005275, 5e-06, 0) (-0.0005275, -5e-06, 0))
  trace_feed_mid.sweep_along_path(trace_feed_mid_path)
  cut_feed_mid_path = polyline((-0.0005275, 0, 0) (-0.00015, 0, 0))
  cut_feed_mid = polyline((-0.0005275, 1.1e-05, 0) (-0.0005275, -1.1e-05, 0))
  cut_feed_mid.sweep_along_path(cut_feed_mid_path)
  trace_feed_out_path = polyline((0.00015, 0, 0) (0.00162, 0, 0))
  trace_feed_out = polyline((0.00015, 5e-06, 0) (0.00015, -5e-06, 0))
  trace_feed_out.sweep_along_path(trace_feed_out_path)
  cut_feed_out_path = polyline((0.00015, 0, 0) (0.00162, 0, 0))
  cut_feed_out = polyline((0.00015, 1.1e-05, 0) (0.00015, -1.1e-05, 0))
  cut_feed_out.sweep_along_path(cut_feed_out_path)
  trace_stub_p_path = polyline((0, 0.0001, 0) (0, 0.00015, 0))
  trace_stub_p = polyline((-5e-06, 0.0001, 0) (5e-06, 0.0001, 0))
  trace_stub_p.sweep_along_path(trace_stub_p_path)
  cut_stub_p_path = polyline((0, 0.0001, 0) (0, 0.00015, 0))
  cut_stub_p = polyline((-1.1e-05, 0.0001, 0) (1.1e-05, 0.0001, 0))
  cut_stub_p.sweep_along_path(cut_stub_p_path)
  lead_a_cj_path = polyline((0.000105501, 0.001615, 0) (9.55e-05, 0.001615, 0))
  lead_a_cj = polyline((0.000105501, 0.00161, 0) (0.000105501, 0.00162, 0))
  lead_a_cj.sweep_along_path(lead_a_cj_path)
  lead_a_sub_cj_path = polyline((0.000105501, 0.001615, 0) (9.55e-05, 0.001615, 0))
  lead_a_sub_cj = polyline((0.000105501, 0.001604, 0) (0.000105501, 0.001626, 0))
  lead_a_sub_cj.sweep_along_path(lead_a_sub_cj_path)
  lead_b_cj_path = polyline((0.000144499, 0.001615, 0) (0.0001545, 0.001615, 0))
  lead_b_cj = polyline((0.000144499, 0.00162, 0) (0.000144499, 0.00161, 0))
  lead_b_cj.sweep_along_path(lead_b_cj_path)
  lead_b_sub_cj_path = polyline((0.000144499, 0.001615, 0) (0.0001545, 0.001615, 0))
  lead_b_sub_cj = polyline((0.000144499, 0.001626, 0) (0.000144499, 0.001604, 0))
  lead_b_sub_cj.sweep_along_path(lead_b_sub_cj_path)
  trace_stub_f_path = polyline((7.55e-05, 0.001615, 0) (9.55e-05, 0.001615, 0))
  trace_stub_f = polyline((7.55e-05, 0.00162, 0) (7.55e-05, 0.00161, 0))
  trace_stub_f.sweep_along_path(trace_stub_f_path)
  cut_stub_f_path = polyline((7.55e-05, 0.001615, 0) (9.55e-05, 0.001615, 0))
  cut_stub_f = polyline((7.55e-05, 0.001626, 0) (7.55e-05, 0.001604, 0))
  cut_stub_f.sweep_along_path(cut_stub_f_path)
  trace_stub_r_path = polyline((0.0001545, 0.001615, 0) (0.0001745, 0.001615, 0))
  trace_stub_r = polyline((0.0001545, 0.00162, 0) (0.0001545, 0.00161, 0))
  trace_stub_r.sweep_along_path(trace_stub_r_path)
  cut_stub_r_path = polyline((0.0001545, 0.001615, 0) (0.0001745, 0.001615, 0))
  cut_stub_r = polyline((0.0001545, 0.001626, 0) (0.0001545, 0.001604, 0))
  cut_stub_r.sweep_along_path(cut_stub_r_path)
  trace_feed_jf_path = polyline((0, 0.000415, 0) (0, 0.001465, 0))
  trace_feed_jf = polyline((-5e-06, 0.000415, 0) (5e-06, 0.000415, 0))
  trace_feed_jf.sweep_along_path(trace_feed_jf_path)
  cut_feed_jf_path = polyline((0, 0.000415, 0) (0, 0.001465, 0))
  cut_feed_jf = polyline((-1.1e-05, 0.000415, 0) (1.1e-05, 0.000415, 0))
  cut_feed_jf.sweep_along_path(cut_feed_jf_path)
  trace_res_open_run_path = polyline((0.00025, 0.001765, 0) (0.00025, 0.002915, 0))
  trace_res_open_run = polyline((0.000245, 0.001765, 0) (0.000255, 0.001765, 0))
  trace_res_open_run.sweep_along_path(trace_res_open_run_path)
  cut_res_open_run_path = polyline((0.00025, 0.001765, 0) (0.00025, 0.002915, 0))
  cut_res_open_run = polyline((0.000239, 0.001765, 0) (0.000261, 0.001765, 0))
  cut_res_open_run.sweep_along_path(cut_res_open_run_path)
  trace_filter_tail_path = polyline(z=0, xy: (0, 0.001765) (0, 0.002285) (-0.00051923387, 0.002285) (-0.00051923387, 0.002055) (-0.00025, 0.002055) (-0.00025, 0.001825) (-0.00051923387, 0.001825) (-0.00051923387, 0.001595) (-0.00025, 0.001595) (-0.00025, 0.001365) (-0.00051923387, 0.001365) (-0.00051923387, 0.001135))
  trace_filter_tail_path.fillet(Vertices=trace_filter_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  trace_filter_tail = polyline((-5e-06, 0.001765, 0) (5e-06, 0.001765, 0))
  trace_filter_tail.sweep_along_path(trace_filter_tail_path)
  cut_filter_tail_path = polyline(z=0, xy: (0, 0.001765) (0, 0.002285) (-0.00051923387, 0.002285) (-0.00051923387, 0.002055) (-0.00025, 0.002055) (-0.00025, 0.001825) (-0.00051923387, 0.001825) (-0.00051923387, 0.001595) (-0.00025, 0.001595) (-0.00025, 0.001365) (-0.00051923387, 0.001365) (-0.00051923387, 0.001135))
  cut_filter_tail_path.fillet(Vertices=cut_filter_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  cut_filter_tail = polyline((-1.1e-05, 0.001765, 0) (1.1e-05, 0.001765, 0))
  cut_filter_tail.sweep_along_path(cut_filter_tail_path)
  trace_res_tail_path = polyline(z=0, xy: (0.00025, 0.001465) (0.00025, 0.000765) (0.00077617693, 0.000765) (0.00077617693, 0.000995) (0.0005, 0.000995) (0.0005, 0.001225) (0.00077617693, 0.001225) (0.00077617693, 0.001455) (0.0005, 0.001455) (0.0005, 0.001685) (0.00077617693, 0.001685) (0.00077617693, 0.001906))
  trace_res_tail_path.fillet(Vertices=trace_res_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  trace_res_tail = polyline((0.000255, 0.001465, 0) (0.000245, 0.001465, 0))
  trace_res_tail.sweep_along_path(trace_res_tail_path)
  cut_res_tail_path = polyline(z=0, xy: (0.00025, 0.001465) (0.00025, 0.000765) (0.00077617693, 0.000765) (0.00077617693, 0.000995) (0.0005, 0.000995) (0.0005, 0.001225) (0.00077617693, 0.001225) (0.00077617693, 0.001455) (0.0005, 0.001455) (0.0005, 0.001685) (0.00077617693, 0.001685) (0.00077617693, 0.001906))
  cut_res_tail_path.fillet(Vertices=cut_res_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  cut_res_tail = polyline((0.000261, 0.001465, 0) (0.000239, 0.001465, 0))
  cut_res_tail.sweep_along_path(cut_res_tail_path)
  g_wb [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.0013441667 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_1 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.0010683333 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_2 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.0005175 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_3 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000885 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_4 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.0012525 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_5 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=5.5e-05 YPadPos=0.000765 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_6 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=5.5e-05 YPadPos=0.001115 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_7 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000305 YPadPos=0.0021483333 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_8 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000305 YPadPos=0.0025316667 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_9 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=5.5e-05 YPadPos=0.002025 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_10 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00025961694 YPadPos=0.00234 ZPadPos=0 XDir=0 YDir=-1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_11 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000195 YPadPos=0.001115 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_12 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00051308846 YPadPos=0.00071 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  plate_cin = polyline(z=0, xy: (-0.0006725, -7e-05) (-0.00067328414, -6.9961478e-05) (-0.00067406072, -6.9846282e-05) (-0.00067482228, -6.9655523e-05) (-0.00067556147, -6.9391036e-05) (-0.00067627117, -6.905537e-05) (-0.00067694456, -6.8651757e-05) (-0.00067757515, -6.8184084e-05) (-0.00067815685, -6.7656854e-05) (-0.00067868408, -6.7075146e-05) (-0.00067915176, -6.6444562e-05) (-0.00067955537, -6.5771174e-05) (-0.00067989104, -6.5061467e-05) (-0.00068015552, -6.4322277e-05) (-0.00068034628, -6.3560723e-05) (-0.00068046148, -6.2784137e-05) (-0.0006805, -6.2e-05) (-0.0006805, 6.2e-05) (-0.00068046148, 6.2784137e-05) (-0.00068034628, 6.3560723e-05) (-0.00068015552, 6.4322277e-05) (-0.00067989104, 6.5061467e-05) (-0.00067955537, 6.5771174e-05) (-0.00067915176, 6.6444562e-05) (-0.00067868408, 6.7075146e-05) (-0.00067815685, 6.7656854e-05) (-0.00067757515, 6.8184084e-05) (-0.00067694456, 6.8651757e-05) (-0.00067627117, 6.905537e-05) (-0.00067556147, 6.9391036e-05) (-0.00067482228, 6.9655523e-05) (-0.00067406072, 6.9846282e-05) (-0.00067328414, 6.9961478e-05) (-0.0006725, 7e-05) (-0.0006475, 7e-05) (-0.00064671586, 6.9961478e-05) (-0.00064593928, 6.9846282e-05) (-0.00064517772, 6.9655523e-05) (-0.00064443853, 6.9391036e-05) (-0.00064372883, 6.905537e-05) (-0.00064305544, 6.8651757e-05) (-0.00064242485, 6.8184084e-05) (-0.00064184315, 6.7656854e-05) (-0.00064131592, 6.7075146e-05) (-0.00064084824, 6.6444562e-05) (-0.00064044463, 6.5771174e-05) (-0.00064010896, 6.5061467e-05) (-0.00063984448, 6.4322277e-05) (-0.00063965372, 6.3560723e-05) (-0.00063953852, 6.2784137e-05) (-0.0006395, 6.2e-05) (-0.0006395, -6.2e-05) (-0.00063953852, -6.2784137e-05) (-0.00063965372, -6.3560723e-05) (-0.00063984448, -6.4322277e-05) (-0.00064010896, -6.5061467e-05) (-0.00064044463, -6.5771174e-05) (-0.00064084824, -6.6444562e-05) (-0.00064131592, -6.7075146e-05) (-0.00064184315, -6.7656854e-05) (-0.00064242485, -6.8184084e-05) (-0.00064305544, -6.8651757e-05) (-0.00064372883, -6.905537e-05) (-0.00064443853, -6.9391036e-05) (-0.00064517772, -6.9655523e-05) (-0.00064593928, -6.9846282e-05) (-0.00064671586, -6.9961478e-05) (-0.0006475, -7e-05) (-0.0006725, -7e-05), closed, covered)
  frame_cin = polyline(z=0, xy: (-0.0006885, -7e-05) (-0.00068846148, -7.0784137e-05) (-0.00068834628, -7.1560723e-05) (-0.00068815552, -7.2322277e-05) (-0.00068789104, -7.3061467e-05) (-0.00068755537, -7.3771174e-05) (-0.00068715176, -7.4444562e-05) (-0.00068668408, -7.5075146e-05) (-0.00068615685, -7.5656854e-05) (-0.00068557515, -7.6184084e-05) (-0.00068494456, -7.6651757e-05) (-0.00068427117, -7.705537e-05) (-0.00068356147, -7.7391036e-05) (-0.00068282228, -7.7655523e-05) (-0.00068206072, -7.7846282e-05) (-0.00068128414, -7.7961478e-05) (-0.0006805, -7.8e-05) (-0.0006395, -7.8e-05) (-0.00063871586, -7.7961478e-05) (-0.00063793928, -7.7846282e-05) (-0.00063717772, -7.7655523e-05) (-0.00063643853, -7.7391036e-05) (-0.00063572883, -7.705537e-05) (-0.00063505544, -7.6651757e-05) (-0.00063442485, -7.6184084e-05) (-0.00063384315, -7.5656854e-05) (-0.00063331592, -7.5075146e-05) (-0.00063284824, -7.4444562e-05) (-0.00063244463, -7.3771174e-05) (-0.00063210896, -7.3061467e-05) (-0.00063184448, -7.2322277e-05) (-0.00063165372, -7.1560723e-05) (-0.00063153852, -7.0784137e-05) (-0.0006315, -7e-05) (-0.0006315, -1.909818e-05) (-0.00063149518, -1.8901939e-05) (-0.00063147111, -1.8412015e-05) (-0.00063143266, -1.80216e-05) (-0.0006313751, -1.7633541e-05) (-0.00063129856, -1.7248774e-05) (-0.00063120324, -1.6868226e-05) (-0.00063108936, -1.6492814e-05) (-0.0006309572, -1.6123441e-05) (-0.00063080707, -1.5760999e-05) (-0.00063063934, -1.540636e-05) (-0.00063045441, -1.5060378e-05) (-0.00063025272, -1.4723887e-05) (-0.00063003477, -1.4397697e-05) (-0.00062980107, -1.4082595e-05) (-0.0006295522, -1.3779339e-05) (-0.00062928874, -1.348866e-05) (-0.00062901134, -1.3211259e-05) (-0.00062872066, -1.2947803e-05) (-0.00062841741, -1.2698928e-05) (-0.0006281023, -1.2465232e-05) (-0.00062777611, -1.2247279e-05) (-0.00062743962, -1.2045594e-05) (-0.00062709364, -1.1860663e-05) (-0.000626739, -1.1692931e-05) (-0.00062637656, -1.1542802e-05) (-0.00062600719, -1.1410639e-05) (-0.00062563177, -1.1296759e-05) (-0.00062525123, -1.1201436e-05) (-0.00062486646, -1.1124902e-05) (-0.0006244784, -1.1067338e-05) (-0.00062408799, -1.1028886e-05) (-0.00062359806, -1.1004817e-05) (-0.00062340182, -1.1e-05) (-0.00057559818, -1.1e-05) (-0.00057540194, -1.1004817e-05) (-0.00057491201, -1.1028886e-05) (-0.0005745216, -1.1067338e-05) (-0.00057413354, -1.1124902e-05) (-0.00057374877, -1.1201436e-05) (-0.00057336823, -1.1296759e-05) (-0.00057299281, -1.1410639e-05) (-0.00057262344, -1.1542802e-05) (-0.000572261, -1.1692931e-05) (-0.00057190636, -1.1860663e-05) (-0.00057156038, -1.2045594e-05) (-0.00057122389, -1.2247279e-05) (-0.0005708977, -1.2465232e-05) (-0.0005705826, -1.2698928e-05) (-0.00057027934, -1.2947803e-05) (-0.00056998866, -1.3211259e-05) (-0.00056971126, -1.348866e-05) (-0.0005694478, -1.3779339e-05) (-0.00056919893, -1.4082595e-05) (-0.00056896523, -1.4397697e-05) (-0.00056874728, -1.4723887e-05) (-0.00056854559, -1.5060378e-05) (-0.00056836066, -1.540636e-05) (-0.00056819293, -1.5760999e-05) (-0.0005680428, -1.6123441e-05) (-0.00056791064, -1.6492814e-05) (-0.00056779676, -1.6868226e-05) (-0.00056770144, -1.7248774e-05) (-0.0005676249, -1.7633541e-05) (-0.00056756734, -1.80216e-05) (-0.00056752889, -1.8412015e-05) (-0.00056750482, -1.8901939e-05) (-0.0005675, -1.909818e-05) (-0.0005675, -0.00012690182) (-0.00056750482, -0.00012709806) (-0.00056752889, -0.00012758798) (-0.00056756734, -0.0001279784) (-0.0005676249, -0.00012836646) (-0.00056770144, -0.00012875123) (-0.00056779676, -0.00012913177) (-0.00056791064, -0.00012950719) (-0.0005680428, -0.00012987656) (-0.00056819293, -0.000130239) (-0.00056836066, -0.00013059364) (-0.00056854559, -0.00013093962) (-0.00056874728, -0.00013127611) (-0.00056896523, -0.0001316023) (-0.00056919893, -0.00013191741) (-0.0005694478, -0.00013222066) (-0.00056971126, -0.00013251134) (-0.00056998866, -0.00013278874) (-0.00057027934, -0.0001330522) (-0.0005705826, -0.00013330107) (-0.0005708977, -0.00013353477) (-0.00057122389, -0.00013375272) (-0.00057156038, -0.00013395441) (-0.00057190636, -0.00013413934) (-0.000572261, -0.00013430707) (-0.00057262344, -0.0001344572) (-0.00057299281, -0.00013458936) (-0.00057336823, -0.00013470324) (-0.00057374877, -0.00013479856) (-0.00057413354, -0.0001348751) (-0.0005745216, -0.00013493266) (-0.00057491201, -0.00013497111) (-0.00057540194, -0.00013499518) (-0.00057559818, -0.000135) (-0.00073240182, -0.000135) (-0.00073259806, -0.00013499518) (-0.00073308798, -0.00013497111) (-0.0007334784, -0.00013493266) (-0.00073386646, -0.0001348751) (-0.00073425123, -0.00013479856) (-0.00073463177, -0.00013470324) (-0.00073500719, -0.00013458936) (-0.00073537656, -0.0001344572) (-0.000735739, -0.00013430707) (-0.00073609364, -0.00013413934) (-0.00073643962, -0.00013395441) (-0.00073677611, -0.00013375272) (-0.0007371023, -0.00013353477) (-0.0007374174, -0.00013330107) (-0.00073772066, -0.0001330522) (-0.00073801134, -0.00013278874) (-0.00073828874, -0.00013251134) (-0.0007385522, -0.00013222066) (-0.00073880107, -0.00013191741) (-0.00073903477, -0.0001316023) (-0.00073925272, -0.00013127611) (-0.00073945441, -0.00013093962) (-0.00073963934, -0.00013059364) (-0.00073980707, -0.000130239) (-0.0007399572, -0.00012987656) (-0.00074008936, -0.00012950719) (-0.00074020324, -0.00012913177) (-0.00074029856, -0.00012875123) (-0.0007403751, -0.00012836646) (-0.00074043266, -0.0001279784) (-0.00074047111, -0.00012758798) (-0.00074049518, -0.00012709806) (-0.0007405, -0.00012690182) (-0.0007405, 0.00012690182) (-0.00074049518, 0.00012709806) (-0.00074047111, 0.00012758798) (-0.00074043266, 0.0001279784) (-0.0007403751, 0.00012836646) (-0.00074029856, 0.00012875123) (-0.00074020324, 0.00012913177) (-0.00074008936, 0.00012950719) (-0.0007399572, 0.00012987656) (-0.00073980707, 0.000130239) (-0.00073963934, 0.00013059364) (-0.00073945441, 0.00013093962) (-0.00073925272, 0.00013127611) (-0.00073903477, 0.0001316023) (-0.00073880107, 0.00013191741) (-0.0007385522, 0.00013222066) (-0.00073828874, 0.00013251134) (-0.00073801134, 0.00013278874) (-0.00073772066, 0.0001330522) (-0.0007374174, 0.00013330107) (-0.0007371023, 0.00013353477) (-0.00073677611, 0.00013375272) (-0.00073643962, 0.00013395441) (-0.00073609364, 0.00013413934) (-0.000735739, 0.00013430707) (-0.00073537656, 0.0001344572) (-0.00073500719, 0.00013458936) (-0.00073463177, 0.00013470324) (-0.00073425123, 0.00013479856) (-0.00073386646, 0.0001348751) (-0.0007334784, 0.00013493266) (-0.00073308798, 0.00013497111) (-0.00073259806, 0.00013499518) (-0.00073240182, 0.000135) (-0.00057559818, 0.000135) (-0.00057540194, 0.00013499518) (-0.00057491201, 0.00013497111) (-0.0005745216, 0.00013493266) (-0.00057413354, 0.0001348751) (-0.00057374877, 0.00013479856) (-0.00057336823, 0.00013470324) (-0.00057299281, 0.00013458936) (-0.00057262344, 0.0001344572) (-0.000572261, 0.00013430707) (-0.00057190636, 0.00013413934) (-0.00057156038, 0.00013395441) (-0.00057122389, 0.00013375272) (-0.0005708977, 0.00013353477) (-0.0005705826, 0.00013330107) (-0.00057027934, 0.0001330522) (-0.00056998866, 0.00013278874) (-0.00056971126, 0.00013251134) (-0.0005694478, 0.00013222066) (-0.00056919893, 0.00013191741) (-0.00056896523, 0.0001316023) (-0.00056874728, 0.00013127611) (-0.00056854559, 0.00013093962) (-0.00056836066, 0.00013059364) (-0.00056819293, 0.000130239) (-0.0005680428, 0.00012987656) (-0.00056791064, 0.00012950719) (-0.00056779676, 0.00012913177) (-0.00056770144, 0.00012875123) (-0.0005676249, 0.00012836646) (-0.00056756734, 0.0001279784) (-0.00056752889, 0.00012758798) (-0.00056750482, 0.00012709806) (-0.0005675, 0.00012690182) (-0.0005675, 1.909818e-05) (-0.00056750482, 1.8901939e-05) (-0.00056752889, 1.8412015e-05) (-0.00056756734, 1.80216e-05) (-0.0005676249, 1.7633541e-05) (-0.00056770144, 1.7248774e-05) (-0.00056779676, 1.6868226e-05) (-0.00056791064, 1.6492814e-05) (-0.0005680428, 1.6123441e-05) (-0.00056819293, 1.5760999e-05) (-0.00056836066, 1.540636e-05) (-0.00056854559, 1.5060378e-05) (-0.00056874728, 1.4723887e-05) (-0.00056896523, 1.4397697e-05) (-0.00056919893, 1.4082595e-05) (-0.0005694478, 1.3779339e-05) (-0.00056971126, 1.348866e-05) (-0.00056998866, 1.3211259e-05) (-0.00057027934, 1.2947803e-05) (-0.0005705826, 1.2698928e-05) (-0.0005708977, 1.2465232e-05) (-0.00057122389, 1.2247279e-05) (-0.00057156038, 1.2045594e-05) (-0.00057190636, 1.1860663e-05) (-0.000572261, 1.1692931e-05) (-0.00057262344, 1.1542802e-05) (-0.00057299281, 1.1410639e-05) (-0.00057336823, 1.1296759e-05) (-0.00057374877, 1.1201436e-05) (-0.00057413354, 1.1124902e-05) (-0.0005745216, 1.1067338e-05) (-0.00057491201, 1.1028886e-05) (-0.00057540194, 1.1004817e-05) (-0.00057559818, 1.1e-05) (-0.00062340182, 1.1e-05) (-0.00062359806, 1.1004817e-05) (-0.00062408799, 1.1028886e-05) (-0.0006244784, 1.1067338e-05) (-0.00062486646, 1.1124902e-05) (-0.00062525123, 1.1201436e-05) (-0.00062563177, 1.1296759e-05) (-0.00062600719, 1.1410639e-05) (-0.00062637656, 1.1542802e-05) (-0.000626739, 1.1692931e-05) (-0.00062709364, 1.1860663e-05) (-0.00062743962, 1.2045594e-05) (-0.00062777611, 1.2247279e-05) (-0.0006281023, 1.2465232e-05) (-0.00062841741, 1.2698928e-05) (-0.00062872066, 1.2947803e-05) (-0.00062901134, 1.3211259e-05) (-0.00062928874, 1.348866e-05) (-0.0006295522, 1.3779339e-05) (-0.00062980107, 1.4082595e-05) (-0.00063003477, 1.4397697e-05) (-0.00063025272, 1.4723887e-05) (-0.00063045441, 1.5060378e-05) (-0.00063063934, 1.540636e-05) (-0.00063080707, 1.5760999e-05) (-0.0006309572, 1.6123441e-05) (-0.00063108936, 1.6492814e-05) (-0.00063120324, 1.6868226e-05)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, closed, covered)
  pocket_cin = polyline(z=0, xy: (-0.0007525, -0.000135) (-0.0007525, 0.000135) (-0.00075244222, 0.00013617621) (-0.00075226942, 0.00013734108) (-0.00075198328, 0.00013848342) (-0.00075158655, 0.0001395922) (-0.00075108306, 0.00014065676) (-0.00075047764, 0.00014166684) (-0.00074977613, 0.00014261272) (-0.00074898528, 0.00014348528) (-0.00074811272, 0.00014427613) (-0.00074716684, 0.00014497764) (-0.00074615676, 0.00014558305) (-0.0007450922, 0.00014608655) (-0.00074398342, 0.00014648328) (-0.00074284108, 0.00014676942) (-0.00074167621, 0.00014694222) (-0.0007405, 0.000147) (-0.0005675, 0.000147) (-0.00056632379, 0.00014694222) (-0.00056515892, 0.00014676942) (-0.00056401658, 0.00014648328) (-0.0005629078, 0.00014608655) (-0.00056184324, 0.00014558305) (-0.00056083316, 0.00014497764) (-0.00055988728, 0.00014427613) (-0.00055901472, 0.00014348528) (-0.00055822388, 0.00014261272) (-0.00055752237, 0.00014166684) (-0.00055691694, 0.00014065676) (-0.00055641345, 0.0001395922) (-0.00055601672, 0.00013848342) (-0.00055573058, 0.00013734108) (-0.00055555778, 0.00013617621) (-0.0005555, 0.000135) (-0.0005555, -0.000135) (-0.00055555778, -0.00013617621) (-0.00055573058, -0.00013734108) (-0.00055601672, -0.00013848342) (-0.00055641345, -0.0001395922) (-0.00055691694, -0.00014065676) (-0.00055752237, -0.00014166684) (-0.00055822388, -0.00014261272) (-0.00055901472, -0.00014348528) (-0.00055988728, -0.00014427613) (-0.00056083316, -0.00014497764) (-0.00056184324, -0.00014558305) (-0.0005629078, -0.00014608655) (-0.00056401658, -0.00014648328) (-0.00056515892, -0.00014676942) (-0.00056632379, -0.00014694222) (-0.0005675, -0.000147) (-0.0007405, -0.000147) (-0.00074167621, -0.00014694222) (-0.00074284108, -0.00014676942) (-0.00074398342, -0.00014648328) (-0.0007450922, -0.00014608655) (-0.00074615676, -0.00014558305) (-0.00074716684, -0.00014497764) (-0.00074811272, -0.00014427613) (-0.00074898528, -0.00014348528) (-0.00074977613, -0.00014261272) (-0.00075047764, -0.00014166684) (-0.00075108306, -0.00014065676) (-0.00075158655, -0.0001395922) (-0.00075198328, -0.00013848342) (-0.00075226942, -0.00013734108) (-0.00075244222, -0.00013617621) (-0.0007525, -0.000135), closed, covered)
  tap_trace_n0 = polyline(z=0, xy: (0.00015, -5e-06) (-0.00015, -5e-06) (-0.00015, 5e-06) (-5e-06, 5e-06) (-5e-06, 0.0001) (5e-06, 0.0001) (5e-06, 5e-06) (0.00015, 5e-06) (0.00015, -5e-06), closed, covered)
  tap_cut_n0 = polyline(z=0, xy: (0.00015, -1.1e-05) (-0.00015, -1.1e-05) (-0.00015, 1.1e-05) (-1.1e-05, 1.1e-05) (-1.1e-05, 0.0001) (1.1e-05, 0.0001) (1.1e-05, 1.1e-05) (0.00015, 1.1e-05) (0.00015, -1.1e-05), closed, covered)
  plate_cp = polyline(z=0, xy: (7e-05, 0.00027) (6.9961478e-05, 0.00026921586) (6.9846282e-05, 0.00026843928) (6.9655523e-05, 0.00026767772) (6.9391036e-05, 0.00026693853) (6.905537e-05, 0.00026622883) (6.8651757e-05, 0.00026555544) (6.8184084e-05, 0.00026492485) (6.7656854e-05, 0.00026434315) (6.7075146e-05, 0.00026381592) (6.6444562e-05, 0.00026334824) (6.5771174e-05, 0.00026294463) (6.5061467e-05, 0.00026260896) (6.4322277e-05, 0.00026234448) (6.3560723e-05, 0.00026215372) (6.2784137e-05, 0.00026203852) (6.2e-05, 0.000262) (-6.2e-05, 0.000262) (-6.2784137e-05, 0.00026203852) (-6.3560723e-05, 0.00026215372) (-6.4322277e-05, 0.00026234448) (-6.5061467e-05, 0.00026260896) (-6.5771174e-05, 0.00026294463) (-6.6444562e-05, 0.00026334824) (-6.7075146e-05, 0.00026381592) (-6.7656854e-05, 0.00026434315) (-6.8184084e-05, 0.00026492485) (-6.8651757e-05, 0.00026555544) (-6.905537e-05, 0.00026622883) (-6.9391036e-05, 0.00026693853) (-6.9655523e-05, 0.00026767772) (-6.9846282e-05, 0.00026843928) (-6.9961478e-05, 0.00026921586) (-7e-05, 0.00027) (-7e-05, 0.000295) (-6.9961478e-05, 0.00029578414) (-6.9846282e-05, 0.00029656072) (-6.9655523e-05, 0.00029732228) (-6.9391036e-05, 0.00029806147) (-6.905537e-05, 0.00029877117) (-6.8651757e-05, 0.00029944456) (-6.8184084e-05, 0.00030007515) (-6.7656854e-05, 0.00030065685) (-6.7075146e-05, 0.00030118408) (-6.6444562e-05, 0.00030165176) (-6.5771174e-05, 0.00030205537) (-6.5061467e-05, 0.00030239104) (-6.4322277e-05, 0.00030265552) (-6.3560723e-05, 0.00030284628) (-6.2784137e-05, 0.00030296148) (-6.2e-05, 0.000303) (6.2e-05, 0.000303) (6.2784137e-05, 0.00030296148) (6.3560723e-05, 0.00030284628) (6.4322277e-05, 0.00030265552) (6.5061467e-05, 0.00030239104) (6.5771174e-05, 0.00030205537) (6.6444562e-05, 0.00030165176) (6.7075146e-05, 0.00030118408) (6.7656854e-05, 0.00030065685) (6.8184084e-05, 0.00030007515) (6.8651757e-05, 0.00029944456) (6.905537e-05, 0.00029877117) (6.9391036e-05, 0.00029806147) (6.9655523e-05, 0.00029732228) (6.9846282e-05, 0.00029656072) (6.9961478e-05, 0.00029578414) (7e-05, 0.000295) (7e-05, 0.00027), closed, covered)
  frame_cp = polyline(z=0, xy: (7e-05, 0.000254) (7.0784137e-05, 0.00025403852) (7.1560723e-05, 0.00025415372) (7.2322277e-05, 0.00025434448) (7.3061467e-05, 0.00025460896) (7.3771174e-05, 0.00025494463) (7.4444562e-05, 0.00025534824) (7.5075146e-05, 0.00025581592) (7.5656854e-05, 0.00025634315) (7.6184084e-05, 0.00025692485) (7.6651757e-05, 0.00025755544) (7.705537e-05, 0.00025822883) (7.7391036e-05, 0.00025893853) (7.7655523e-05, 0.00025967772) (7.7846282e-05, 0.00026043928) (7.7961478e-05, 0.00026121586) (7.8e-05, 0.000262) (7.8e-05, 0.000303) (7.7961478e-05, 0.00030378414) (7.7846282e-05, 0.00030456072) (7.7655523e-05, 0.00030532228) (7.7391036e-05, 0.00030606147) (7.705537e-05, 0.00030677117) (7.6651757e-05, 0.00030744456) (7.6184084e-05, 0.00030807515) (7.5656854e-05, 0.00030865685) (7.5075146e-05, 0.00030918408) (7.4444562e-05, 0.00030965176) (7.3771174e-05, 0.00031005537) (7.3061467e-05, 0.00031039104) (7.2322277e-05, 0.00031065552) (7.1560723e-05, 0.00031084628) (7.0784137e-05, 0.00031096148) (7e-05, 0.000311) (1.909818e-05, 0.000311) (1.8901939e-05, 0.00031100482) (1.8412015e-05, 0.00031102889) (1.80216e-05, 0.00031106734) (1.7633541e-05, 0.0003111249) (1.7248774e-05, 0.00031120144) (1.6868226e-05, 0.00031129676) (1.6492814e-05, 0.00031141064) (1.6123441e-05, 0.0003115428) (1.5760999e-05, 0.00031169293) (1.540636e-05, 0.00031186066) (1.5060378e-05, 0.00031204559) (1.4723887e-05, 0.00031224728) (1.4397697e-05, 0.00031246523) (1.4082595e-05, 0.00031269893) (1.3779339e-05, 0.0003129478) (1.348866e-05, 0.00031321126) (1.3211259e-05, 0.00031348866) (1.2947803e-05, 0.00031377934) (1.2698928e-05, 0.00031408259) (1.2465232e-05, 0.0003143977) (1.2247279e-05, 0.00031472389) (1.2045594e-05, 0.00031506038) (1.1860663e-05, 0.00031540636) (1.1692931e-05, 0.000315761) (1.1542802e-05, 0.00031612344) (1.1410639e-05, 0.00031649281) (1.1296759e-05, 0.00031686823) (1.1201436e-05, 0.00031724877) (1.1124902e-05, 0.00031763354) (1.1067338e-05, 0.0003180216) (1.1028886e-05, 0.00031841202) (1.1004817e-05, 0.00031890194) (1.1e-05, 0.00031909818) (1.1e-05, 0.00036690182) (1.1004817e-05, 0.00036709806) (1.1028886e-05, 0.00036758799) (1.1067338e-05, 0.0003679784) (1.1124902e-05, 0.00036836646) (1.1201436e-05, 0.00036875123) (1.1296759e-05, 0.00036913177) (1.1410639e-05, 0.00036950719) (1.1542802e-05, 0.00036987656) (1.1692931e-05, 0.000370239) (1.1860663e-05, 0.00037059364) (1.2045594e-05, 0.00037093962) (1.2247279e-05, 0.00037127611) (1.2465232e-05, 0.0003716023) (1.2698928e-05, 0.0003719174) (1.2947803e-05, 0.00037222066) (1.3211259e-05, 0.00037251134) (1.348866e-05, 0.00037278874) (1.3779339e-05, 0.0003730522) (1.4082595e-05, 0.00037330107) (1.4397697e-05, 0.00037353477) (1.4723887e-05, 0.00037375272) (1.5060378e-05, 0.00037395441) (1.540636e-05, 0.00037413934) (1.5760999e-05, 0.00037430707) (1.6123441e-05, 0.0003744572) (1.6492814e-05, 0.00037458936) (1.6868226e-05, 0.00037470324) (1.7248774e-05, 0.00037479856) (1.7633541e-05, 0.0003748751) (1.80216e-05, 0.00037493266) (1.8412015e-05, 0.00037497111) (1.8901939e-05, 0.00037499518) (1.909818e-05, 0.000375) (0.00012690182, 0.000375) (0.00012709806, 0.00037499518) (0.00012758798, 0.00037497111) (0.0001279784, 0.00037493266) (0.00012836646, 0.0003748751) (0.00012875123, 0.00037479856) (0.00012913177, 0.00037470324) (0.00012950719, 0.00037458936) (0.00012987656, 0.0003744572) (0.000130239, 0.00037430707) (0.00013059364, 0.00037413934) (0.00013093962, 0.00037395441) (0.00013127611, 0.00037375272) (0.0001316023, 0.00037353477) (0.00013191741, 0.00037330107) (0.00013222066, 0.0003730522) (0.00013251134, 0.00037278874) (0.00013278874, 0.00037251134) (0.0001330522, 0.00037222066) (0.00013330107, 0.0003719174) (0.00013353477, 0.0003716023) (0.00013375272, 0.00037127611) (0.00013395441, 0.00037093962) (0.00013413934, 0.00037059364) (0.00013430707, 0.000370239) (0.0001344572, 0.00036987656) (0.00013458936, 0.00036950719) (0.00013470324, 0.00036913177) (0.00013479856, 0.00036875123) (0.0001348751, 0.00036836646) (0.00013493266, 0.0003679784) (0.00013497111, 0.00036758799) (0.00013499518, 0.00036709806) (0.000135, 0.00036690182) (0.000135, 0.00021009818) (0.00013499518, 0.00020990194) (0.00013497111, 0.00020941201) (0.00013493266, 0.0002090216) (0.0001348751, 0.00020863354) (0.00013479856, 0.00020824877) (0.00013470324, 0.00020786823) (0.00013458936, 0.00020749281) (0.0001344572, 0.00020712344) (0.00013430707, 0.000206761) (0.00013413934, 0.00020640636) (0.00013395441, 0.00020606038) (0.00013375272, 0.00020572389) (0.00013353477, 0.0002053977) (0.00013330107, 0.00020508259) (0.0001330522, 0.00020477934) (0.00013278874, 0.00020448866) (0.00013251134, 0.00020421126) (0.00013222066, 0.0002039478) (0.00013191741, 0.00020369893) (0.0001316023, 0.00020346523) (0.00013127611, 0.00020324728) (0.00013093962, 0.00020304559) (0.00013059364, 0.00020286066) (0.000130239, 0.00020269293) (0.00012987656, 0.0002025428) (0.00012950719, 0.00020241064) (0.00012913177, 0.00020229676) (0.00012875123, 0.00020220144) (0.00012836646, 0.0002021249) (0.0001279784, 0.00020206734) (0.00012758798, 0.00020202889) (0.00012709806, 0.00020200482) (0.00012690182, 0.000202) (-0.00012690182, 0.000202) (-0.00012709806, 0.00020200482) (-0.00012758798, 0.00020202889) (-0.0001279784, 0.00020206734) (-0.00012836646, 0.0002021249) (-0.00012875123, 0.00020220144) (-0.00012913177, 0.00020229676) (-0.00012950719, 0.00020241064) (-0.00012987656, 0.0002025428) (-0.000130239, 0.00020269293) (-0.00013059364, 0.00020286066) (-0.00013093962, 0.00020304559) (-0.00013127611, 0.00020324728) (-0.0001316023, 0.00020346523) (-0.00013191741, 0.00020369893) (-0.00013222066, 0.0002039478) (-0.00013251134, 0.00020421126) (-0.00013278874, 0.00020448866) (-0.0001330522, 0.00020477934) (-0.00013330107, 0.00020508259) (-0.00013353477, 0.0002053977) (-0.00013375272, 0.00020572389) (-0.00013395441, 0.00020606038) (-0.00013413934, 0.00020640636) (-0.00013430707, 0.000206761) (-0.0001344572, 0.00020712344) (-0.00013458936, 0.00020749281) (-0.00013470324, 0.00020786823) (-0.00013479856, 0.00020824877) (-0.0001348751, 0.00020863354) (-0.00013493266, 0.0002090216) (-0.00013497111, 0.00020941201) (-0.00013499518, 0.00020990194) (-0.000135, 0.00021009818) (-0.000135, 0.00036690182) (-0.00013499518, 0.00036709806) (-0.00013497111, 0.00036758799) (-0.00013493266, 0.0003679784) (-0.0001348751, 0.00036836646) (-0.00013479856, 0.00036875123) (-0.00013470324, 0.00036913177) (-0.00013458936, 0.00036950719) (-0.0001344572, 0.00036987656) (-0.00013430707, 0.000370239) (-0.00013413934, 0.00037059364) (-0.00013395441, 0.00037093962) (-0.00013375272, 0.00037127611) (-0.00013353477, 0.0003716023) (-0.00013330107, 0.0003719174) (-0.0001330522, 0.00037222066) (-0.00013278874, 0.00037251134) (-0.00013251134, 0.00037278874) (-0.00013222066, 0.0003730522) (-0.00013191741, 0.00037330107) (-0.0001316023, 0.00037353477) (-0.00013127611, 0.00037375272) (-0.00013093962, 0.00037395441) (-0.00013059364, 0.00037413934) (-0.000130239, 0.00037430707) (-0.00012987656, 0.0003744572) (-0.00012950719, 0.00037458936) (-0.00012913177, 0.00037470324) (-0.00012875123, 0.00037479856) (-0.00012836646, 0.0003748751) (-0.0001279784, 0.00037493266) (-0.00012758798, 0.00037497111) (-0.00012709806, 0.00037499518) (-0.00012690182, 0.000375) (-1.909818e-05, 0.000375) (-1.8901939e-05, 0.00037499518) (-1.8412015e-05, 0.00037497111) (-1.80216e-05, 0.00037493266) (-1.7633541e-05, 0.0003748751) (-1.7248774e-05, 0.00037479856) (-1.6868226e-05, 0.00037470324) (-1.6492814e-05, 0.00037458936) (-1.6123441e-05, 0.0003744572) (-1.5760999e-05, 0.00037430707) (-1.540636e-05, 0.00037413934) (-1.5060378e-05, 0.00037395441) (-1.4723887e-05, 0.00037375272) (-1.4397697e-05, 0.00037353477) (-1.4082595e-05, 0.00037330107) (-1.3779339e-05, 0.0003730522) (-1.348866e-05, 0.00037278874) (-1.3211259e-05, 0.00037251134) (-1.2947803e-05, 0.00037222066) (-1.2698928e-05, 0.0003719174) (-1.2465232e-05, 0.0003716023) (-1.2247279e-05, 0.00037127611) (-1.2045594e-05, 0.00037093962) (-1.1860663e-05, 0.00037059364) (-1.1692931e-05, 0.000370239) (-1.1542802e-05, 0.00036987656) (-1.1410639e-05, 0.00036950719) (-1.1296759e-05, 0.00036913177) (-1.1201436e-05, 0.00036875123) (-1.1124902e-05, 0.00036836646) (-1.1067338e-05, 0.0003679784) (-1.1028886e-05, 0.00036758799) (-1.1004817e-05, 0.00036709806) (-1.1e-05, 0.00036690182) (-1.1e-05, 0.00031909818) (-1.1004817e-05, 0.00031890194) (-1.1028886e-05, 0.00031841202) (-1.1067338e-05, 0.0003180216) (-1.1124902e-05, 0.00031763354) (-1.1201436e-05, 0.00031724877) (-1.1296759e-05, 0.00031686823) (-1.1410639e-05, 0.00031649281) (-1.1542802e-05, 0.00031612344) (-1.1692931e-05, 0.000315761) (-1.1860663e-05, 0.00031540636) (-1.2045594e-05, 0.00031506038) (-1.2247279e-05, 0.00031472389) (-1.2465232e-05, 0.0003143977) (-1.2698928e-05, 0.00031408259) (-1.2947803e-05, 0.00031377934) (-1.3211259e-05, 0.00031348866) (-1.348866e-05, 0.00031321126) (-1.3779339e-05, 0.0003129478) (-1.4082595e-05, 0.00031269893) (-1.4397697e-05, 0.00031246523) (-1.4723887e-05, 0.00031224728) (-1.5060378e-05, 0.00031204559) (-1.540636e-05, 0.00031186066) (-1.5760999e-05, 0.00031169293) (-1.6123441e-05, 0.0003115428) (-1.6492814e-05, 0.00031141064) (-1.6868226e-05, 0.00031129676)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, closed, covered)
  pocket_cp = polyline(z=0, xy: (0.000135, 0.00019) (-0.000135, 0.00019) (-0.00013617621, 0.00019005778) (-0.00013734108, 0.00019023058) (-0.00013848342, 0.00019051672) (-0.0001395922, 0.00019091345) (-0.00014065676, 0.00019141694) (-0.00014166684, 0.00019202237) (-0.00014261272, 0.00019272388) (-0.00014348528, 0.00019351472) (-0.00014427613, 0.00019438728) (-0.00014497764, 0.00019533316) (-0.00014558305, 0.00019634324) (-0.00014608655, 0.0001974078) (-0.00014648328, 0.00019851658) (-0.00014676942, 0.00019965892) (-0.00014694222, 0.00020082379) (-0.000147, 0.000202) (-0.000147, 0.000375) (-0.00014694222, 0.00037617621) (-0.00014676942, 0.00037734108) (-0.00014648328, 0.00037848342) (-0.00014608655, 0.0003795922) (-0.00014558305, 0.00038065676) (-0.00014497764, 0.00038166684) (-0.00014427613, 0.00038261272) (-0.00014348528, 0.00038348528) (-0.00014261272, 0.00038427613) (-0.00014166684, 0.00038497764) (-0.00014065676, 0.00038558305) (-0.0001395922, 0.00038608655) (-0.00013848342, 0.00038648328) (-0.00013734108, 0.00038676942) (-0.00013617621, 0.00038694222) (-0.000135, 0.000387) (0.000135, 0.000387) (0.00013617621, 0.00038694222) (0.00013734108, 0.00038676942) (0.00013848342, 0.00038648328) (0.0001395922, 0.00038608655) (0.00014065676, 0.00038558305) (0.00014166684, 0.00038497764) (0.00014261272, 0.00038427613) (0.00014348528, 0.00038348528) (0.00014427613, 0.00038261272) (0.00014497764, 0.00038166684) (0.00014558305, 0.00038065676) (0.00014608655, 0.0003795922) (0.00014648328, 0.00037848342) (0.00014676942, 0.00037734108) (0.00014694222, 0.00037617621) (0.000147, 0.000375) (0.000147, 0.000202) (0.00014694222, 0.00020082379) (0.00014676942, 0.00019965892) (0.00014648328, 0.00019851658) (0.00014608655, 0.0001974078) (0.00014558305, 0.00019634324) (0.00014497764, 0.00019533316) (0.00014427613, 0.00019438728) (0.00014348528, 0.00019351472) (0.00014261272, 0.00019272388) (0.00014166684, 0.00019202237) (0.00014065676, 0.00019141694) (0.0001395922, 0.00019091345) (0.00013848342, 0.00019051672) (0.00013734108, 0.00019023058) (0.00013617621, 0.00019005778) (0.000135, 0.00019), closed, covered)
  tap_trace_jf = polyline(z=0, xy: (-5e-06, 0.001465) (-5e-06, 0.001765) (5e-06, 0.001765) (5e-06, 0.00162) (7.55e-05, 0.00162) (7.55e-05, 0.00161) (5e-06, 0.00161) (5e-06, 0.001465) (-5e-06, 0.001465), closed, covered)
  tap_cut_jf = polyline(z=0, xy: (-1.1e-05, 0.001465) (-1.1e-05, 0.001765) (1.1e-05, 0.001765) (1.1e-05, 0.001626) (7.55e-05, 0.001626) (7.55e-05, 0.001604) (1.1e-05, 0.001604) (1.1e-05, 0.001465) (-1.1e-05, 0.001465), closed, covered)
  tap_trace_jr = polyline(z=0, xy: (0.0001745, 0.00162) (0.000245, 0.00162) (0.000245, 0.001765) (0.000255, 0.001765) (0.000255, 0.001465) (0.000245, 0.001465) (0.000245, 0.00161) (0.0001745, 0.00161) (0.0001745, 0.00162), closed, covered)
  tap_cut_jr = polyline(z=0, xy: (0.0001745, 0.001626) (0.000239, 0.001626) (0.000239, 0.001765) (0.000261, 0.001765) (0.000261, 0.001465) (0.000239, 0.001465) (0.000239, 0.001604) (0.0001745, 0.001604) (0.0001745, 0.001626), closed, covered)
  head_a_cj = polyline(z=0, xy: (0.0001075, 0.001596) (0.00010730397, 0.0015960096) (0.00010710982, 0.0015960384) (0.00010691943, 0.0015960861) (0.00010673463, 0.0015961522) (0.00010655721, 0.0015962362) (0.00010638886, 0.0015963371) (0.00010623121, 0.001596454) (0.00010608579, 0.0015965858) (0.00010595398, 0.0015967312) (0.00010583706, 0.0015968889) (0.00010573616, 0.0015970572) (0.00010565224, 0.0015972346) (0.00010558612, 0.0015974194) (0.00010553843, 0.0015976098) (0.00010550963, 0.001597804) (0.0001055, 0.001598) (0.0001055, 0.001632) (0.00010550963, 0.001632196) (0.00010553843, 0.0016323902) (0.00010558612, 0.0016325806) (0.00010565224, 0.0016327654) (0.00010573616, 0.0016329428) (0.00010583706, 0.0016331111) (0.00010595398, 0.0016332688) (0.00010608579, 0.0016334142) (0.00010623121, 0.001633546) (0.00010638886, 0.0016336629) (0.00010655721, 0.0016337638) (0.00010673463, 0.0016338478) (0.00010691943, 0.0016339139) (0.00010710982, 0.0016339616) (0.00010730397, 0.0016339904) (0.0001075, 0.001634) (0.0001185, 0.001634) (0.00011869603, 0.0016339904) (0.00011889018, 0.0016339616) (0.00011908057, 0.0016339139) (0.00011926537, 0.0016338478) (0.00011944279, 0.0016337638) (0.00011961114, 0.0016336629) (0.00011976879, 0.001633546) (0.00011991421, 0.0016334142) (0.00012004602, 0.0016332688) (0.00012016294, 0.0016331111) (0.00012026384, 0.0016329428) (0.00012034776, 0.0016327654) (0.00012041388, 0.0016325806) (0.00012046157, 0.0016323902) (0.00012049037, 0.001632196) (0.0001205, 0.001632) (0.0001205, 0.001598) (0.00012049037, 0.001597804) (0.00012046157, 0.0015976098) (0.00012041388, 0.0015974194) (0.00012034776, 0.0015972346) (0.00012026384, 0.0015970572) (0.00012016294, 0.0015968889) (0.00012004602, 0.0015967312) (0.00011991421, 0.0015965858) (0.00011976879, 0.001596454) (0.00011961114, 0.0015963371) (0.00011944279, 0.0015962362) (0.00011926537, 0.0015961522) (0.00011908057, 0.0015960861) (0.00011889018, 0.0015960384) (0.00011869603, 0.0015960096) (0.0001185, 0.001596) (0.0001075, 0.001596), closed, covered)
  head_b_cj = polyline(z=0, xy: (0.0001315, 0.001596) (0.00013130397, 0.0015960096) (0.00013110982, 0.0015960384) (0.00013091943, 0.0015960861) (0.00013073463, 0.0015961522) (0.00013055721, 0.0015962362) (0.00013038886, 0.0015963371) (0.00013023121, 0.001596454) (0.00013008579, 0.0015965858) (0.00012995398, 0.0015967312) (0.00012983706, 0.0015968889) (0.00012973616, 0.0015970572) (0.00012965224, 0.0015972346) (0.00012958612, 0.0015974194) (0.00012953843, 0.0015976098) (0.00012950963, 0.001597804) (0.0001295, 0.001598) (0.0001295, 0.001632) (0.00012950963, 0.001632196) (0.00012953843, 0.0016323902) (0.00012958612, 0.0016325806) (0.00012965224, 0.0016327654) (0.00012973616, 0.0016329428) (0.00012983706, 0.0016331111) (0.00012995398, 0.0016332688) (0.00013008579, 0.0016334142) (0.00013023121, 0.001633546) (0.00013038886, 0.0016336629) (0.00013055721, 0.0016337638) (0.00013073463, 0.0016338478) (0.00013091943, 0.0016339139) (0.00013110982, 0.0016339616) (0.00013130397, 0.0016339904) (0.0001315, 0.001634) (0.0001425, 0.001634) (0.00014269603, 0.0016339904) (0.00014289018, 0.0016339616) (0.00014308057, 0.0016339139) (0.00014326537, 0.0016338478) (0.00014344279, 0.0016337638) (0.00014361114, 0.0016336629) (0.00014376879, 0.001633546) (0.00014391421, 0.0016334142) (0.00014404602, 0.0016332688) (0.00014416294, 0.0016331111) (0.00014426384, 0.0016329428) (0.00014434776, 0.0016327654) (0.00014441388, 0.0016325806) (0.00014446157, 0.0016323902) (0.00014449037, 0.001632196) (0.0001445, 0.001632) (0.0001445, 0.001598) (0.00014449037, 0.001597804) (0.00014446157, 0.0015976098) (0.00014441388, 0.0015974194) (0.00014434776, 0.0015972346) (0.00014426384, 0.0015970572) (0.00014416294, 0.0015968889) (0.00014404602, 0.0015967312) (0.00014391421, 0.0015965858) (0.00014376879, 0.001596454) (0.00014361114, 0.0015963371) (0.00014344279, 0.0015962362) (0.00014326537, 0.0015961522) (0.00014308057, 0.0015960861) (0.00014289018, 0.0015960384) (0.00014269603, 0.0015960096) (0.0001425, 0.001596) (0.0001315, 0.001596), closed, covered)
  pocket_cj = polyline(z=0, xy: (9.75e-05, 0.001586) (9.7303966e-05, 0.0015860096) (9.7109819e-05, 0.0015860384) (9.6919431e-05, 0.0015860861) (9.6734633e-05, 0.0015861522) (9.6557207e-05, 0.0015862362) (9.638886e-05, 0.0015863371) (9.6231213e-05, 0.001586454) (9.6085786e-05, 0.0015865858) (9.5953979e-05, 0.0015867312) (9.5837061e-05, 0.0015868889) (9.5736157e-05, 0.0015870572) (9.5652241e-05, 0.0015872346) (9.5586119e-05, 0.0015874194) (9.5538429e-05, 0.0015876098) (9.5509631e-05, 0.001587804) (9.55e-05, 0.001588) (9.55e-05, 0.001642) (9.5509631e-05, 0.001642196) (9.5538429e-05, 0.0016423902) (9.5586119e-05, 0.0016425806) (9.5652241e-05, 0.0016427654) (9.5736157e-05, 0.0016429428) (9.5837061e-05, 0.0016431111) (9.5953979e-05, 0.0016432688) (9.6085786e-05, 0.0016434142) (9.6231213e-05, 0.001643546) (9.638886e-05, 0.0016436629) (9.6557207e-05, 0.0016437638) (9.6734633e-05, 0.0016438478) (9.6919431e-05, 0.0016439139) (9.7109819e-05, 0.0016439616) (9.7303966e-05, 0.0016439904) (9.75e-05, 0.001644) (0.0001525, 0.001644) (0.00015269603, 0.0016439904) (0.00015289018, 0.0016439616) (0.00015308057, 0.0016439139) (0.00015326537, 0.0016438478) (0.00015344279, 0.0016437638) (0.00015361114, 0.0016436629) (0.00015376879, 0.001643546) (0.00015391421, 0.0016434142) (0.00015404602, 0.0016432688) (0.00015416294, 0.0016431111) (0.00015426384, 0.0016429428) (0.00015434776, 0.0016427654) (0.00015441388, 0.0016425806) (0.00015446157, 0.0016423902) (0.00015449037, 0.001642196) (0.0001545, 0.001642) (0.0001545, 0.001588) (0.00015449037, 0.001587804) (0.00015446157, 0.0015876098) (0.00015441388, 0.0015874194) (0.00015434776, 0.0015872346) (0.00015426384, 0.0015870572) (0.00015416294, 0.0015868889) (0.00015404602, 0.0015867312) (0.00015391421, 0.0015865858) (0.00015376879, 0.001586454) (0.00015361114, 0.0015863371) (0.00015344279, 0.0015862362) (0.00015326537, 0.0015861522) (0.00015308057, 0.0015860861) (0.00015289018, 0.0015860384) (0.00015269603, 0.0015860096) (0.0001525, 0.001586) (9.75e-05, 0.001586), closed, covered)
  open_to_ground_readout_open = rectangle(corner=(0.000239, 0.002915, 0), x_size=2.2e-05, y_size=6e-06)
  endcap_feed_in_start = rectangle(corner=(-0.001626, -1.1e-05, 0), x_size=6e-06, y_size=2.2e-05)
  endcap_feed_out_end = rectangle(corner=(0.00162, -1.1e-05, 0), x_size=6e-06, y_size=2.2e-05)
  ground_main_plane = rectangle(corner=(-0.00182, -0.000347, 0), x_size=0.00364, y_size=0.003468)
  main [silicon_eps11p45] = box(corner=(-0.00182, -0.000347, -0.0005), size=(0.00364, 0.003468, 0.0005))
  sample_holder [vacuum] = box(corner=(-0.00182, -0.000347, -0.00165), size=(0.00364, 0.003468, 0.00254))
  ground_main_plane.subtract(pocket_cp, tap_cut_jr, pocket_cj, tap_cut_n0, cut_stub_p, open_to_ground_readout_open, cut_stub_r, endcap_feed_in_start, lead_a_sub_cp, lead_b_sub_cj, cut_filter_tail, endcap_feed_out_end, cut_stub_f, pocket_cin, cut_feed_in, lead_b_sub_cin, lead_b_sub_cp, cut_feed_mid, lead_a_sub_cj, lead_a_sub_cin, cut_res_tail, tap_cut_jf, cut_feed_out, cut_res_open_run, cut_feed_jf)
  Port_feed_in_start = rectangle(corner=(-0.001626, -5e-06, 0), x_size=6e-06, y_size=1e-05)
  voltage_line_Port_feed_in_start = polyline((-0.00162, 0, 0) (-0.001626, 0, 0))
  Port_feed_out_end = rectangle(corner=(0.00162, -5e-06, 0), x_size=6e-06, y_size=1e-05)
  voltage_line_Port_feed_out_end = polyline((0.00162, 0, 0) (0.001626, 0, 0))
boundaries and excitations:
  RLCBoundary_feed_in_start: Lumped RLC Objects=Port_feed_in_start CurrentLine{middle of Port_feed_in_start.edge(x at corner) -> middle of Port_feed_in_start.edge(x opposite corner)} RLC_Type=Parallel Resistance=50ohm
  RLCBoundary_feed_out_end: Lumped RLC Objects=Port_feed_out_end CurrentLine{middle of Port_feed_out_end.edge(x at corner) -> middle of Port_feed_out_end.edge(x opposite corner)} RLC_Type=Parallel Resistance=50ohm
  PerfE: Perfect E Objects=[lead_a_cin, lead_b_cin, lead_a_cp, lead_b_cp, trace_feed_in, trace_feed_mid, trace_feed_out, trace_stub_p, lead_a_cj, lead_b_cj, trace_stub_f, trace_stub_r, trace_feed_jf, trace_res_open_run, trace_filter_tail, trace_res_tail, plate_cin, frame_cin, tap_trace_n0, plate_cp, frame_cp, tap_trace_jf, tap_trace_jr, head_a_cj, head_b_cj, ground_main_plane]
mesh:
  port_mesh: LengthBased Objects=[Port_feed_in_start, Port_feed_out_end] MaxLength=7um
  cpw_line_mesh: LengthBased Objects=[lead_a_cin, lead_b_cin, trace_feed_in, trace_feed_mid, trace_feed_out, trace_stub_p, trace_stub_f, trace_stub_r, trace_feed_jf, trace_res_open_run, trace_filter_tail, trace_res_tail, plate_cin, frame_cin, tap_trace_n0, tap_trace_jf, tap_trace_jr] MaxLength=20um
  cap_mesh: LengthBased Objects=[lead_a_cp, lead_b_cp, lead_a_cj, lead_b_cj, plate_cp, frame_cp, head_a_cj, head_b_cj] MaxLength=9um
setups:
  Setup: HfssEigen MinimumFrequency=5.95GHz NumModes=2 MaxDeltaFreq=0.1 ConvergeOnRealFreq=true MaximumPasses=15 MinimumPasses=3 MinimumConvergedPasses=2 PercentRefinement=20 BasisOrder=1
source amplitudes:
  #-10:1: 1 0deg
  #-10:2: 0 0deg
reports:
  Freq. vs. pass: re(Mode(1)), re(Mode(2)) vs Pass on Setup : AdaptivePass

design P250g9_straps_m50um_1824_hfss (HFSS, Eigenmode, model units mm)
geometry:
  lead_a_cin_path = polyline((-0.000740499, 0, 0) (-0.0007925, 0, 0))
  lead_a_cin = polyline((-0.000740499, -5e-06, 0) (-0.000740499, 5e-06, 0))
  lead_a_cin.sweep_along_path(lead_a_cin_path)
  lead_a_sub_cin_path = polyline((-0.000740499, 0, 0) (-0.0007925, 0, 0))
  lead_a_sub_cin = polyline((-0.000740499, -1.1e-05, 0) (-0.000740499, 1.1e-05, 0))
  lead_a_sub_cin.sweep_along_path(lead_a_sub_cin_path)
  lead_b_cin_path = polyline((-0.000639501, 0, 0) (-0.0005275, 0, 0))
  lead_b_cin = polyline((-0.000639501, 5e-06, 0) (-0.000639501, -5e-06, 0))
  lead_b_cin.sweep_along_path(lead_b_cin_path)
  lead_b_sub_cin_path = polyline((-0.000639501, 0, 0) (-0.0005275, 0, 0))
  lead_b_sub_cin = polyline((-0.000639501, 1.1e-05, 0) (-0.000639501, -1.1e-05, 0))
  lead_b_sub_cin.sweep_along_path(lead_b_sub_cin_path)
  lead_a_cp_path = polyline((0, 0.000202001, 0) (0, 0.00015, 0))
  lead_a_cp = polyline((5e-06, 0.000202001, 0) (-5e-06, 0.000202001, 0))
  lead_a_cp.sweep_along_path(lead_a_cp_path)
  lead_a_sub_cp_path = polyline((0, 0.000202001, 0) (0, 0.00015, 0))
  lead_a_sub_cp = polyline((1.1e-05, 0.000202001, 0) (-1.1e-05, 0.000202001, 0))
  lead_a_sub_cp.sweep_along_path(lead_a_sub_cp_path)
  lead_b_cp_path = polyline((0, 0.000302999, 0) (0, 0.000415, 0))
  lead_b_cp = polyline((-5e-06, 0.000302999, 0) (5e-06, 0.000302999, 0))
  lead_b_cp.sweep_along_path(lead_b_cp_path)
  lead_b_sub_cp_path = polyline((0, 0.000302999, 0) (0, 0.000415, 0))
  lead_b_sub_cp = polyline((-1.1e-05, 0.000302999, 0) (1.1e-05, 0.000302999, 0))
  lead_b_sub_cp.sweep_along_path(lead_b_sub_cp_path)
  trace_feed_in_path = polyline((-0.00162, 0, 0) (-0.0007925, 0, 0))
  trace_feed_in = polyline((-0.00162, 5e-06, 0) (-0.00162, -5e-06, 0))
  trace_feed_in.sweep_along_path(trace_feed_in_path)
  cut_feed_in_path = polyline((-0.00162, 0, 0) (-0.0007925, 0, 0))
  cut_feed_in = polyline((-0.00162, 1.1e-05, 0) (-0.00162, -1.1e-05, 0))
  cut_feed_in.sweep_along_path(cut_feed_in_path)
  trace_feed_mid_path = polyline((-0.0005275, 0, 0) (-0.00015, 0, 0))
  trace_feed_mid = polyline((-0.0005275, 5e-06, 0) (-0.0005275, -5e-06, 0))
  trace_feed_mid.sweep_along_path(trace_feed_mid_path)
  cut_feed_mid_path = polyline((-0.0005275, 0, 0) (-0.00015, 0, 0))
  cut_feed_mid = polyline((-0.0005275, 1.1e-05, 0) (-0.0005275, -1.1e-05, 0))
  cut_feed_mid.sweep_along_path(cut_feed_mid_path)
  trace_feed_out_path = polyline((0.00015, 0, 0) (0.00162, 0, 0))
  trace_feed_out = polyline((0.00015, 5e-06, 0) (0.00015, -5e-06, 0))
  trace_feed_out.sweep_along_path(trace_feed_out_path)
  cut_feed_out_path = polyline((0.00015, 0, 0) (0.00162, 0, 0))
  cut_feed_out = polyline((0.00015, 1.1e-05, 0) (0.00015, -1.1e-05, 0))
  cut_feed_out.sweep_along_path(cut_feed_out_path)
  trace_stub_p_path = polyline((0, 0.0001, 0) (0, 0.00015, 0))
  trace_stub_p = polyline((-5e-06, 0.0001, 0) (5e-06, 0.0001, 0))
  trace_stub_p.sweep_along_path(trace_stub_p_path)
  cut_stub_p_path = polyline((0, 0.0001, 0) (0, 0.00015, 0))
  cut_stub_p = polyline((-1.1e-05, 0.0001, 0) (1.1e-05, 0.0001, 0))
  cut_stub_p.sweep_along_path(cut_stub_p_path)
  lead_a_cj_path = polyline((0.000105501, 0.001615, 0) (9.55e-05, 0.001615, 0))
  lead_a_cj = polyline((0.000105501, 0.00161, 0) (0.000105501, 0.00162, 0))
  lead_a_cj.sweep_along_path(lead_a_cj_path)
  lead_a_sub_cj_path = polyline((0.000105501, 0.001615, 0) (9.55e-05, 0.001615, 0))
  lead_a_sub_cj = polyline((0.000105501, 0.001604, 0) (0.000105501, 0.001626, 0))
  lead_a_sub_cj.sweep_along_path(lead_a_sub_cj_path)
  lead_b_cj_path = polyline((0.000144499, 0.001615, 0) (0.0001545, 0.001615, 0))
  lead_b_cj = polyline((0.000144499, 0.00162, 0) (0.000144499, 0.00161, 0))
  lead_b_cj.sweep_along_path(lead_b_cj_path)
  lead_b_sub_cj_path = polyline((0.000144499, 0.001615, 0) (0.0001545, 0.001615, 0))
  lead_b_sub_cj = polyline((0.000144499, 0.001626, 0) (0.000144499, 0.001604, 0))
  lead_b_sub_cj.sweep_along_path(lead_b_sub_cj_path)
  trace_stub_f_path = polyline((7.55e-05, 0.001615, 0) (9.55e-05, 0.001615, 0))
  trace_stub_f = polyline((7.55e-05, 0.00162, 0) (7.55e-05, 0.00161, 0))
  trace_stub_f.sweep_along_path(trace_stub_f_path)
  cut_stub_f_path = polyline((7.55e-05, 0.001615, 0) (9.55e-05, 0.001615, 0))
  cut_stub_f = polyline((7.55e-05, 0.001626, 0) (7.55e-05, 0.001604, 0))
  cut_stub_f.sweep_along_path(cut_stub_f_path)
  trace_stub_r_path = polyline((0.0001545, 0.001615, 0) (0.0001745, 0.001615, 0))
  trace_stub_r = polyline((0.0001545, 0.00162, 0) (0.0001545, 0.00161, 0))
  trace_stub_r.sweep_along_path(trace_stub_r_path)
  cut_stub_r_path = polyline((0.0001545, 0.001615, 0) (0.0001745, 0.001615, 0))
  cut_stub_r = polyline((0.0001545, 0.001626, 0) (0.0001545, 0.001604, 0))
  cut_stub_r.sweep_along_path(cut_stub_r_path)
  trace_feed_jf_path = polyline((0, 0.000415, 0) (0, 0.001465, 0))
  trace_feed_jf = polyline((-5e-06, 0.000415, 0) (5e-06, 0.000415, 0))
  trace_feed_jf.sweep_along_path(trace_feed_jf_path)
  cut_feed_jf_path = polyline((0, 0.000415, 0) (0, 0.001465, 0))
  cut_feed_jf = polyline((-1.1e-05, 0.000415, 0) (1.1e-05, 0.000415, 0))
  cut_feed_jf.sweep_along_path(cut_feed_jf_path)
  trace_res_open_run_path = polyline((0.00025, 0.001765, 0) (0.00025, 0.002915, 0))
  trace_res_open_run = polyline((0.000245, 0.001765, 0) (0.000255, 0.001765, 0))
  trace_res_open_run.sweep_along_path(trace_res_open_run_path)
  cut_res_open_run_path = polyline((0.00025, 0.001765, 0) (0.00025, 0.002915, 0))
  cut_res_open_run = polyline((0.000239, 0.001765, 0) (0.000261, 0.001765, 0))
  cut_res_open_run.sweep_along_path(cut_res_open_run_path)
  trace_filter_tail_path = polyline(z=0, xy: (0, 0.001765) (0, 0.002285) (-0.00051923387, 0.002285) (-0.00051923387, 0.002055) (-0.00025, 0.002055) (-0.00025, 0.001825) (-0.00051923387, 0.001825) (-0.00051923387, 0.001595) (-0.00025, 0.001595) (-0.00025, 0.001365) (-0.00051923387, 0.001365) (-0.00051923387, 0.001135))
  trace_filter_tail_path.fillet(Vertices=trace_filter_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  trace_filter_tail = polyline((-5e-06, 0.001765, 0) (5e-06, 0.001765, 0))
  trace_filter_tail.sweep_along_path(trace_filter_tail_path)
  cut_filter_tail_path = polyline(z=0, xy: (0, 0.001765) (0, 0.002285) (-0.00051923387, 0.002285) (-0.00051923387, 0.002055) (-0.00025, 0.002055) (-0.00025, 0.001825) (-0.00051923387, 0.001825) (-0.00051923387, 0.001595) (-0.00025, 0.001595) (-0.00025, 0.001365) (-0.00051923387, 0.001365) (-0.00051923387, 0.001135))
  cut_filter_tail_path.fillet(Vertices=cut_filter_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  cut_filter_tail = polyline((-1.1e-05, 0.001765, 0) (1.1e-05, 0.001765, 0))
  cut_filter_tail.sweep_along_path(cut_filter_tail_path)
  trace_res_tail_path = polyline(z=0, xy: (0.00025, 0.001465) (0.00025, 0.000765) (0.00077617693, 0.000765) (0.00077617693, 0.000995) (0.0005, 0.000995) (0.0005, 0.001225) (0.00077617693, 0.001225) (0.00077617693, 0.001455) (0.0005, 0.001455) (0.0005, 0.001685) (0.00077617693, 0.001685) (0.00077617693, 0.001865))
  trace_res_tail_path.fillet(Vertices=trace_res_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  trace_res_tail = polyline((0.000255, 0.001465, 0) (0.000245, 0.001465, 0))
  trace_res_tail.sweep_along_path(trace_res_tail_path)
  cut_res_tail_path = polyline(z=0, xy: (0.00025, 0.001465) (0.00025, 0.000765) (0.00077617693, 0.000765) (0.00077617693, 0.000995) (0.0005, 0.000995) (0.0005, 0.001225) (0.00077617693, 0.001225) (0.00077617693, 0.001455) (0.0005, 0.001455) (0.0005, 0.001685) (0.00077617693, 0.001685) (0.00077617693, 0.001865))
  cut_res_tail_path.fillet(Vertices=cut_res_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  cut_res_tail = polyline((0.000261, 0.001465, 0) (0.000239, 0.001465, 0))
  cut_res_tail.sweep_along_path(cut_res_tail_path)
  g_wb [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.0013441667 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_1 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.0010683333 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_2 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.0005175 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_3 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000885 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_4 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.0012525 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_5 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=5.5e-05 YPadPos=0.000765 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_6 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=5.5e-05 YPadPos=0.001115 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_7 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000305 YPadPos=0.0021483333 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_8 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000305 YPadPos=0.0025316667 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_9 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=5.5e-05 YPadPos=0.002025 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_10 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00025961694 YPadPos=0.00234 ZPadPos=0 XDir=0 YDir=-1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_11 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000195 YPadPos=0.001115 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_12 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00051308846 YPadPos=0.00071 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  plate_cin = polyline(z=0, xy: (-0.0006725, -7e-05) (-0.00067328414, -6.9961478e-05) (-0.00067406072, -6.9846282e-05) (-0.00067482228, -6.9655523e-05) (-0.00067556147, -6.9391036e-05) (-0.00067627117, -6.905537e-05) (-0.00067694456, -6.8651757e-05) (-0.00067757515, -6.8184084e-05) (-0.00067815685, -6.7656854e-05) (-0.00067868408, -6.7075146e-05) (-0.00067915176, -6.6444562e-05) (-0.00067955537, -6.5771174e-05) (-0.00067989104, -6.5061467e-05) (-0.00068015552, -6.4322277e-05) (-0.00068034628, -6.3560723e-05) (-0.00068046148, -6.2784137e-05) (-0.0006805, -6.2e-05) (-0.0006805, 6.2e-05) (-0.00068046148, 6.2784137e-05) (-0.00068034628, 6.3560723e-05) (-0.00068015552, 6.4322277e-05) (-0.00067989104, 6.5061467e-05) (-0.00067955537, 6.5771174e-05) (-0.00067915176, 6.6444562e-05) (-0.00067868408, 6.7075146e-05) (-0.00067815685, 6.7656854e-05) (-0.00067757515, 6.8184084e-05) (-0.00067694456, 6.8651757e-05) (-0.00067627117, 6.905537e-05) (-0.00067556147, 6.9391036e-05) (-0.00067482228, 6.9655523e-05) (-0.00067406072, 6.9846282e-05) (-0.00067328414, 6.9961478e-05) (-0.0006725, 7e-05) (-0.0006475, 7e-05) (-0.00064671586, 6.9961478e-05) (-0.00064593928, 6.9846282e-05) (-0.00064517772, 6.9655523e-05) (-0.00064443853, 6.9391036e-05) (-0.00064372883, 6.905537e-05) (-0.00064305544, 6.8651757e-05) (-0.00064242485, 6.8184084e-05) (-0.00064184315, 6.7656854e-05) (-0.00064131592, 6.7075146e-05) (-0.00064084824, 6.6444562e-05) (-0.00064044463, 6.5771174e-05) (-0.00064010896, 6.5061467e-05) (-0.00063984448, 6.4322277e-05) (-0.00063965372, 6.3560723e-05) (-0.00063953852, 6.2784137e-05) (-0.0006395, 6.2e-05) (-0.0006395, -6.2e-05) (-0.00063953852, -6.2784137e-05) (-0.00063965372, -6.3560723e-05) (-0.00063984448, -6.4322277e-05) (-0.00064010896, -6.5061467e-05) (-0.00064044463, -6.5771174e-05) (-0.00064084824, -6.6444562e-05) (-0.00064131592, -6.7075146e-05) (-0.00064184315, -6.7656854e-05) (-0.00064242485, -6.8184084e-05) (-0.00064305544, -6.8651757e-05) (-0.00064372883, -6.905537e-05) (-0.00064443853, -6.9391036e-05) (-0.00064517772, -6.9655523e-05) (-0.00064593928, -6.9846282e-05) (-0.00064671586, -6.9961478e-05) (-0.0006475, -7e-05) (-0.0006725, -7e-05), closed, covered)
  frame_cin = polyline(z=0, xy: (-0.0006885, -7e-05) (-0.00068846148, -7.0784137e-05) (-0.00068834628, -7.1560723e-05) (-0.00068815552, -7.2322277e-05) (-0.00068789104, -7.3061467e-05) (-0.00068755537, -7.3771174e-05) (-0.00068715176, -7.4444562e-05) (-0.00068668408, -7.5075146e-05) (-0.00068615685, -7.5656854e-05) (-0.00068557515, -7.6184084e-05) (-0.00068494456, -7.6651757e-05) (-0.00068427117, -7.705537e-05) (-0.00068356147, -7.7391036e-05) (-0.00068282228, -7.7655523e-05) (-0.00068206072, -7.7846282e-05) (-0.00068128414, -7.7961478e-05) (-0.0006805, -7.8e-05) (-0.0006395, -7.8e-05) (-0.00063871586, -7.7961478e-05) (-0.00063793928, -7.7846282e-05) (-0.00063717772, -7.7655523e-05) (-0.00063643853, -7.7391036e-05) (-0.00063572883, -7.705537e-05) (-0.00063505544, -7.6651757e-05) (-0.00063442485, -7.6184084e-05) (-0.00063384315, -7.5656854e-05) (-0.00063331592, -7.5075146e-05) (-0.00063284824, -7.4444562e-05) (-0.00063244463, -7.3771174e-05) (-0.00063210896, -7.3061467e-05) (-0.00063184448, -7.2322277e-05) (-0.00063165372, -7.1560723e-05) (-0.00063153852, -7.0784137e-05) (-0.0006315, -7e-05) (-0.0006315, -1.909818e-05) (-0.00063149518, -1.8901939e-05) (-0.00063147111, -1.8412015e-05) (-0.00063143266, -1.80216e-05) (-0.0006313751, -1.7633541e-05) (-0.00063129856, -1.7248774e-05) (-0.00063120324, -1.6868226e-05) (-0.00063108936, -1.6492814e-05) (-0.0006309572, -1.6123441e-05) (-0.00063080707, -1.5760999e-05) (-0.00063063934, -1.540636e-05) (-0.00063045441, -1.5060378e-05) (-0.00063025272, -1.4723887e-05) (-0.00063003477, -1.4397697e-05) (-0.00062980107, -1.4082595e-05) (-0.0006295522, -1.3779339e-05) (-0.00062928874, -1.348866e-05) (-0.00062901134, -1.3211259e-05) (-0.00062872066, -1.2947803e-05) (-0.00062841741, -1.2698928e-05) (-0.0006281023, -1.2465232e-05) (-0.00062777611, -1.2247279e-05) (-0.00062743962, -1.2045594e-05) (-0.00062709364, -1.1860663e-05) (-0.000626739, -1.1692931e-05) (-0.00062637656, -1.1542802e-05) (-0.00062600719, -1.1410639e-05) (-0.00062563177, -1.1296759e-05) (-0.00062525123, -1.1201436e-05) (-0.00062486646, -1.1124902e-05) (-0.0006244784, -1.1067338e-05) (-0.00062408799, -1.1028886e-05) (-0.00062359806, -1.1004817e-05) (-0.00062340182, -1.1e-05) (-0.00057559818, -1.1e-05) (-0.00057540194, -1.1004817e-05) (-0.00057491201, -1.1028886e-05) (-0.0005745216, -1.1067338e-05) (-0.00057413354, -1.1124902e-05) (-0.00057374877, -1.1201436e-05) (-0.00057336823, -1.1296759e-05) (-0.00057299281, -1.1410639e-05) (-0.00057262344, -1.1542802e-05) (-0.000572261, -1.1692931e-05) (-0.00057190636, -1.1860663e-05) (-0.00057156038, -1.2045594e-05) (-0.00057122389, -1.2247279e-05) (-0.0005708977, -1.2465232e-05) (-0.0005705826, -1.2698928e-05) (-0.00057027934, -1.2947803e-05) (-0.00056998866, -1.3211259e-05) (-0.00056971126, -1.348866e-05) (-0.0005694478, -1.3779339e-05) (-0.00056919893, -1.4082595e-05) (-0.00056896523, -1.4397697e-05) (-0.00056874728, -1.4723887e-05) (-0.00056854559, -1.5060378e-05) (-0.00056836066, -1.540636e-05) (-0.00056819293, -1.5760999e-05) (-0.0005680428, -1.6123441e-05) (-0.00056791064, -1.6492814e-05) (-0.00056779676, -1.6868226e-05) (-0.00056770144, -1.7248774e-05) (-0.0005676249, -1.7633541e-05) (-0.00056756734, -1.80216e-05) (-0.00056752889, -1.8412015e-05) (-0.00056750482, -1.8901939e-05) (-0.0005675, -1.909818e-05) (-0.0005675, -0.00012690182) (-0.00056750482, -0.00012709806) (-0.00056752889, -0.00012758798) (-0.00056756734, -0.0001279784) (-0.0005676249, -0.00012836646) (-0.00056770144, -0.00012875123) (-0.00056779676, -0.00012913177) (-0.00056791064, -0.00012950719) (-0.0005680428, -0.00012987656) (-0.00056819293, -0.000130239) (-0.00056836066, -0.00013059364) (-0.00056854559, -0.00013093962) (-0.00056874728, -0.00013127611) (-0.00056896523, -0.0001316023) (-0.00056919893, -0.00013191741) (-0.0005694478, -0.00013222066) (-0.00056971126, -0.00013251134) (-0.00056998866, -0.00013278874) (-0.00057027934, -0.0001330522) (-0.0005705826, -0.00013330107) (-0.0005708977, -0.00013353477) (-0.00057122389, -0.00013375272) (-0.00057156038, -0.00013395441) (-0.00057190636, -0.00013413934) (-0.000572261, -0.00013430707) (-0.00057262344, -0.0001344572) (-0.00057299281, -0.00013458936) (-0.00057336823, -0.00013470324) (-0.00057374877, -0.00013479856) (-0.00057413354, -0.0001348751) (-0.0005745216, -0.00013493266) (-0.00057491201, -0.00013497111) (-0.00057540194, -0.00013499518) (-0.00057559818, -0.000135) (-0.00073240182, -0.000135) (-0.00073259806, -0.00013499518) (-0.00073308798, -0.00013497111) (-0.0007334784, -0.00013493266) (-0.00073386646, -0.0001348751) (-0.00073425123, -0.00013479856) (-0.00073463177, -0.00013470324) (-0.00073500719, -0.00013458936) (-0.00073537656, -0.0001344572) (-0.000735739, -0.00013430707) (-0.00073609364, -0.00013413934) (-0.00073643962, -0.00013395441) (-0.00073677611, -0.00013375272) (-0.0007371023, -0.00013353477) (-0.0007374174, -0.00013330107) (-0.00073772066, -0.0001330522) (-0.00073801134, -0.00013278874) (-0.00073828874, -0.00013251134) (-0.0007385522, -0.00013222066) (-0.00073880107, -0.00013191741) (-0.00073903477, -0.0001316023) (-0.00073925272, -0.00013127611) (-0.00073945441, -0.00013093962) (-0.00073963934, -0.00013059364) (-0.00073980707, -0.000130239) (-0.0007399572, -0.00012987656) (-0.00074008936, -0.00012950719) (-0.00074020324, -0.00012913177) (-0.00074029856, -0.00012875123) (-0.0007403751, -0.00012836646) (-0.00074043266, -0.0001279784) (-0.00074047111, -0.00012758798) (-0.00074049518, -0.00012709806) (-0.0007405, -0.00012690182) (-0.0007405, 0.00012690182) (-0.00074049518, 0.00012709806) (-0.00074047111, 0.00012758798) (-0.00074043266, 0.0001279784) (-0.0007403751, 0.00012836646) (-0.00074029856, 0.00012875123) (-0.00074020324, 0.00012913177) (-0.00074008936, 0.00012950719) (-0.0007399572, 0.00012987656) (-0.00073980707, 0.000130239) (-0.00073963934, 0.00013059364) (-0.00073945441, 0.00013093962) (-0.00073925272, 0.00013127611) (-0.00073903477, 0.0001316023) (-0.00073880107, 0.00013191741) (-0.0007385522, 0.00013222066) (-0.00073828874, 0.00013251134) (-0.00073801134, 0.00013278874) (-0.00073772066, 0.0001330522) (-0.0007374174, 0.00013330107) (-0.0007371023, 0.00013353477) (-0.00073677611, 0.00013375272) (-0.00073643962, 0.00013395441) (-0.00073609364, 0.00013413934) (-0.000735739, 0.00013430707) (-0.00073537656, 0.0001344572) (-0.00073500719, 0.00013458936) (-0.00073463177, 0.00013470324) (-0.00073425123, 0.00013479856) (-0.00073386646, 0.0001348751) (-0.0007334784, 0.00013493266) (-0.00073308798, 0.00013497111) (-0.00073259806, 0.00013499518) (-0.00073240182, 0.000135) (-0.00057559818, 0.000135) (-0.00057540194, 0.00013499518) (-0.00057491201, 0.00013497111) (-0.0005745216, 0.00013493266) (-0.00057413354, 0.0001348751) (-0.00057374877, 0.00013479856) (-0.00057336823, 0.00013470324) (-0.00057299281, 0.00013458936) (-0.00057262344, 0.0001344572) (-0.000572261, 0.00013430707) (-0.00057190636, 0.00013413934) (-0.00057156038, 0.00013395441) (-0.00057122389, 0.00013375272) (-0.0005708977, 0.00013353477) (-0.0005705826, 0.00013330107) (-0.00057027934, 0.0001330522) (-0.00056998866, 0.00013278874) (-0.00056971126, 0.00013251134) (-0.0005694478, 0.00013222066) (-0.00056919893, 0.00013191741) (-0.00056896523, 0.0001316023) (-0.00056874728, 0.00013127611) (-0.00056854559, 0.00013093962) (-0.00056836066, 0.00013059364) (-0.00056819293, 0.000130239) (-0.0005680428, 0.00012987656) (-0.00056791064, 0.00012950719) (-0.00056779676, 0.00012913177) (-0.00056770144, 0.00012875123) (-0.0005676249, 0.00012836646) (-0.00056756734, 0.0001279784) (-0.00056752889, 0.00012758798) (-0.00056750482, 0.00012709806) (-0.0005675, 0.00012690182) (-0.0005675, 1.909818e-05) (-0.00056750482, 1.8901939e-05) (-0.00056752889, 1.8412015e-05) (-0.00056756734, 1.80216e-05) (-0.0005676249, 1.7633541e-05) (-0.00056770144, 1.7248774e-05) (-0.00056779676, 1.6868226e-05) (-0.00056791064, 1.6492814e-05) (-0.0005680428, 1.6123441e-05) (-0.00056819293, 1.5760999e-05) (-0.00056836066, 1.540636e-05) (-0.00056854559, 1.5060378e-05) (-0.00056874728, 1.4723887e-05) (-0.00056896523, 1.4397697e-05) (-0.00056919893, 1.4082595e-05) (-0.0005694478, 1.3779339e-05) (-0.00056971126, 1.348866e-05) (-0.00056998866, 1.3211259e-05) (-0.00057027934, 1.2947803e-05) (-0.0005705826, 1.2698928e-05) (-0.0005708977, 1.2465232e-05) (-0.00057122389, 1.2247279e-05) (-0.00057156038, 1.2045594e-05) (-0.00057190636, 1.1860663e-05) (-0.000572261, 1.1692931e-05) (-0.00057262344, 1.1542802e-05) (-0.00057299281, 1.1410639e-05) (-0.00057336823, 1.1296759e-05) (-0.00057374877, 1.1201436e-05) (-0.00057413354, 1.1124902e-05) (-0.0005745216, 1.1067338e-05) (-0.00057491201, 1.1028886e-05) (-0.00057540194, 1.1004817e-05) (-0.00057559818, 1.1e-05) (-0.00062340182, 1.1e-05) (-0.00062359806, 1.1004817e-05) (-0.00062408799, 1.1028886e-05) (-0.0006244784, 1.1067338e-05) (-0.00062486646, 1.1124902e-05) (-0.00062525123, 1.1201436e-05) (-0.00062563177, 1.1296759e-05) (-0.00062600719, 1.1410639e-05) (-0.00062637656, 1.1542802e-05) (-0.000626739, 1.1692931e-05) (-0.00062709364, 1.1860663e-05) (-0.00062743962, 1.2045594e-05) (-0.00062777611, 1.2247279e-05) (-0.0006281023, 1.2465232e-05) (-0.00062841741, 1.2698928e-05) (-0.00062872066, 1.2947803e-05) (-0.00062901134, 1.3211259e-05) (-0.00062928874, 1.348866e-05) (-0.0006295522, 1.3779339e-05) (-0.00062980107, 1.4082595e-05) (-0.00063003477, 1.4397697e-05) (-0.00063025272, 1.4723887e-05) (-0.00063045441, 1.5060378e-05) (-0.00063063934, 1.540636e-05) (-0.00063080707, 1.5760999e-05) (-0.0006309572, 1.6123441e-05) (-0.00063108936, 1.6492814e-05) (-0.00063120324, 1.6868226e-05)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, closed, covered)
  pocket_cin = polyline(z=0, xy: (-0.0007525, -0.000135) (-0.0007525, 0.000135) (-0.00075244222, 0.00013617621) (-0.00075226942, 0.00013734108) (-0.00075198328, 0.00013848342) (-0.00075158655, 0.0001395922) (-0.00075108306, 0.00014065676) (-0.00075047764, 0.00014166684) (-0.00074977613, 0.00014261272) (-0.00074898528, 0.00014348528) (-0.00074811272, 0.00014427613) (-0.00074716684, 0.00014497764) (-0.00074615676, 0.00014558305) (-0.0007450922, 0.00014608655) (-0.00074398342, 0.00014648328) (-0.00074284108, 0.00014676942) (-0.00074167621, 0.00014694222) (-0.0007405, 0.000147) (-0.0005675, 0.000147) (-0.00056632379, 0.00014694222) (-0.00056515892, 0.00014676942) (-0.00056401658, 0.00014648328) (-0.0005629078, 0.00014608655) (-0.00056184324, 0.00014558305) (-0.00056083316, 0.00014497764) (-0.00055988728, 0.00014427613) (-0.00055901472, 0.00014348528) (-0.00055822388, 0.00014261272) (-0.00055752237, 0.00014166684) (-0.00055691694, 0.00014065676) (-0.00055641345, 0.0001395922) (-0.00055601672, 0.00013848342) (-0.00055573058, 0.00013734108) (-0.00055555778, 0.00013617621) (-0.0005555, 0.000135) (-0.0005555, -0.000135) (-0.00055555778, -0.00013617621) (-0.00055573058, -0.00013734108) (-0.00055601672, -0.00013848342) (-0.00055641345, -0.0001395922) (-0.00055691694, -0.00014065676) (-0.00055752237, -0.00014166684) (-0.00055822388, -0.00014261272) (-0.00055901472, -0.00014348528) (-0.00055988728, -0.00014427613) (-0.00056083316, -0.00014497764) (-0.00056184324, -0.00014558305) (-0.0005629078, -0.00014608655) (-0.00056401658, -0.00014648328) (-0.00056515892, -0.00014676942) (-0.00056632379, -0.00014694222) (-0.0005675, -0.000147) (-0.0007405, -0.000147) (-0.00074167621, -0.00014694222) (-0.00074284108, -0.00014676942) (-0.00074398342, -0.00014648328) (-0.0007450922, -0.00014608655) (-0.00074615676, -0.00014558305) (-0.00074716684, -0.00014497764) (-0.00074811272, -0.00014427613) (-0.00074898528, -0.00014348528) (-0.00074977613, -0.00014261272) (-0.00075047764, -0.00014166684) (-0.00075108306, -0.00014065676) (-0.00075158655, -0.0001395922) (-0.00075198328, -0.00013848342) (-0.00075226942, -0.00013734108) (-0.00075244222, -0.00013617621) (-0.0007525, -0.000135), closed, covered)
  tap_trace_n0 = polyline(z=0, xy: (0.00015, -5e-06) (-0.00015, -5e-06) (-0.00015, 5e-06) (-5e-06, 5e-06) (-5e-06, 0.0001) (5e-06, 0.0001) (5e-06, 5e-06) (0.00015, 5e-06) (0.00015, -5e-06), closed, covered)
  tap_cut_n0 = polyline(z=0, xy: (0.00015, -1.1e-05) (-0.00015, -1.1e-05) (-0.00015, 1.1e-05) (-1.1e-05, 1.1e-05) (-1.1e-05, 0.0001) (1.1e-05, 0.0001) (1.1e-05, 1.1e-05) (0.00015, 1.1e-05) (0.00015, -1.1e-05), closed, covered)
  plate_cp = polyline(z=0, xy: (7e-05, 0.00027) (6.9961478e-05, 0.00026921586) (6.9846282e-05, 0.00026843928) (6.9655523e-05, 0.00026767772) (6.9391036e-05, 0.00026693853) (6.905537e-05, 0.00026622883) (6.8651757e-05, 0.00026555544) (6.8184084e-05, 0.00026492485) (6.7656854e-05, 0.00026434315) (6.7075146e-05, 0.00026381592) (6.6444562e-05, 0.00026334824) (6.5771174e-05, 0.00026294463) (6.5061467e-05, 0.00026260896) (6.4322277e-05, 0.00026234448) (6.3560723e-05, 0.00026215372) (6.2784137e-05, 0.00026203852) (6.2e-05, 0.000262) (-6.2e-05, 0.000262) (-6.2784137e-05, 0.00026203852) (-6.3560723e-05, 0.00026215372) (-6.4322277e-05, 0.00026234448) (-6.5061467e-05, 0.00026260896) (-6.5771174e-05, 0.00026294463) (-6.6444562e-05, 0.00026334824) (-6.7075146e-05, 0.00026381592) (-6.7656854e-05, 0.00026434315) (-6.8184084e-05, 0.00026492485) (-6.8651757e-05, 0.00026555544) (-6.905537e-05, 0.00026622883) (-6.9391036e-05, 0.00026693853) (-6.9655523e-05, 0.00026767772) (-6.9846282e-05, 0.00026843928) (-6.9961478e-05, 0.00026921586) (-7e-05, 0.00027) (-7e-05, 0.000295) (-6.9961478e-05, 0.00029578414) (-6.9846282e-05, 0.00029656072) (-6.9655523e-05, 0.00029732228) (-6.9391036e-05, 0.00029806147) (-6.905537e-05, 0.00029877117) (-6.8651757e-05, 0.00029944456) (-6.8184084e-05, 0.00030007515) (-6.7656854e-05, 0.00030065685) (-6.7075146e-05, 0.00030118408) (-6.6444562e-05, 0.00030165176) (-6.5771174e-05, 0.00030205537) (-6.5061467e-05, 0.00030239104) (-6.4322277e-05, 0.00030265552) (-6.3560723e-05, 0.00030284628) (-6.2784137e-05, 0.00030296148) (-6.2e-05, 0.000303) (6.2e-05, 0.000303) (6.2784137e-05, 0.00030296148) (6.3560723e-05, 0.00030284628) (6.4322277e-05, 0.00030265552) (6.5061467e-05, 0.00030239104) (6.5771174e-05, 0.00030205537) (6.6444562e-05, 0.00030165176) (6.7075146e-05, 0.00030118408) (6.7656854e-05, 0.00030065685) (6.8184084e-05, 0.00030007515) (6.8651757e-05, 0.00029944456) (6.905537e-05, 0.00029877117) (6.9391036e-05, 0.00029806147) (6.9655523e-05, 0.00029732228) (6.9846282e-05, 0.00029656072) (6.9961478e-05, 0.00029578414) (7e-05, 0.000295) (7e-05, 0.00027), closed, covered)
  frame_cp = polyline(z=0, xy: (7e-05, 0.000254) (7.0784137e-05, 0.00025403852) (7.1560723e-05, 0.00025415372) (7.2322277e-05, 0.00025434448) (7.3061467e-05, 0.00025460896) (7.3771174e-05, 0.00025494463) (7.4444562e-05, 0.00025534824) (7.5075146e-05, 0.00025581592) (7.5656854e-05, 0.00025634315) (7.6184084e-05, 0.00025692485) (7.6651757e-05, 0.00025755544) (7.705537e-05, 0.00025822883) (7.7391036e-05, 0.00025893853) (7.7655523e-05, 0.00025967772) (7.7846282e-05, 0.00026043928) (7.7961478e-05, 0.00026121586) (7.8e-05, 0.000262) (7.8e-05, 0.000303) (7.7961478e-05, 0.00030378414) (7.7846282e-05, 0.00030456072) (7.7655523e-05, 0.00030532228) (7.7391036e-05, 0.00030606147) (7.705537e-05, 0.00030677117) (7.6651757e-05, 0.00030744456) (7.6184084e-05, 0.00030807515) (7.5656854e-05, 0.00030865685) (7.5075146e-05, 0.00030918408) (7.4444562e-05, 0.00030965176) (7.3771174e-05, 0.00031005537) (7.3061467e-05, 0.00031039104) (7.2322277e-05, 0.00031065552) (7.1560723e-05, 0.00031084628) (7.0784137e-05, 0.00031096148) (7e-05, 0.000311) (1.909818e-05, 0.000311) (1.8901939e-05, 0.00031100482) (1.8412015e-05, 0.00031102889) (1.80216e-05, 0.00031106734) (1.7633541e-05, 0.0003111249) (1.7248774e-05, 0.00031120144) (1.6868226e-05, 0.00031129676) (1.6492814e-05, 0.00031141064) (1.6123441e-05, 0.0003115428) (1.5760999e-05, 0.00031169293) (1.540636e-05, 0.00031186066) (1.5060378e-05, 0.00031204559) (1.4723887e-05, 0.00031224728) (1.4397697e-05, 0.00031246523) (1.4082595e-05, 0.00031269893) (1.3779339e-05, 0.0003129478) (1.348866e-05, 0.00031321126) (1.3211259e-05, 0.00031348866) (1.2947803e-05, 0.00031377934) (1.2698928e-05, 0.00031408259) (1.2465232e-05, 0.0003143977) (1.2247279e-05, 0.00031472389) (1.2045594e-05, 0.00031506038) (1.1860663e-05, 0.00031540636) (1.1692931e-05, 0.000315761) (1.1542802e-05, 0.00031612344) (1.1410639e-05, 0.00031649281) (1.1296759e-05, 0.00031686823) (1.1201436e-05, 0.00031724877) (1.1124902e-05, 0.00031763354) (1.1067338e-05, 0.0003180216) (1.1028886e-05, 0.00031841202) (1.1004817e-05, 0.00031890194) (1.1e-05, 0.00031909818) (1.1e-05, 0.00036690182) (1.1004817e-05, 0.00036709806) (1.1028886e-05, 0.00036758799) (1.1067338e-05, 0.0003679784) (1.1124902e-05, 0.00036836646) (1.1201436e-05, 0.00036875123) (1.1296759e-05, 0.00036913177) (1.1410639e-05, 0.00036950719) (1.1542802e-05, 0.00036987656) (1.1692931e-05, 0.000370239) (1.1860663e-05, 0.00037059364) (1.2045594e-05, 0.00037093962) (1.2247279e-05, 0.00037127611) (1.2465232e-05, 0.0003716023) (1.2698928e-05, 0.0003719174) (1.2947803e-05, 0.00037222066) (1.3211259e-05, 0.00037251134) (1.348866e-05, 0.00037278874) (1.3779339e-05, 0.0003730522) (1.4082595e-05, 0.00037330107) (1.4397697e-05, 0.00037353477) (1.4723887e-05, 0.00037375272) (1.5060378e-05, 0.00037395441) (1.540636e-05, 0.00037413934) (1.5760999e-05, 0.00037430707) (1.6123441e-05, 0.0003744572) (1.6492814e-05, 0.00037458936) (1.6868226e-05, 0.00037470324) (1.7248774e-05, 0.00037479856) (1.7633541e-05, 0.0003748751) (1.80216e-05, 0.00037493266) (1.8412015e-05, 0.00037497111) (1.8901939e-05, 0.00037499518) (1.909818e-05, 0.000375) (0.00012690182, 0.000375) (0.00012709806, 0.00037499518) (0.00012758798, 0.00037497111) (0.0001279784, 0.00037493266) (0.00012836646, 0.0003748751) (0.00012875123, 0.00037479856) (0.00012913177, 0.00037470324) (0.00012950719, 0.00037458936) (0.00012987656, 0.0003744572) (0.000130239, 0.00037430707) (0.00013059364, 0.00037413934) (0.00013093962, 0.00037395441) (0.00013127611, 0.00037375272) (0.0001316023, 0.00037353477) (0.00013191741, 0.00037330107) (0.00013222066, 0.0003730522) (0.00013251134, 0.00037278874) (0.00013278874, 0.00037251134) (0.0001330522, 0.00037222066) (0.00013330107, 0.0003719174) (0.00013353477, 0.0003716023) (0.00013375272, 0.00037127611) (0.00013395441, 0.00037093962) (0.00013413934, 0.00037059364) (0.00013430707, 0.000370239) (0.0001344572, 0.00036987656) (0.00013458936, 0.00036950719) (0.00013470324, 0.00036913177) (0.00013479856, 0.00036875123) (0.0001348751, 0.00036836646) (0.00013493266, 0.0003679784) (0.00013497111, 0.00036758799) (0.00013499518, 0.00036709806) (0.000135, 0.00036690182) (0.000135, 0.00021009818) (0.00013499518, 0.00020990194) (0.00013497111, 0.00020941201) (0.00013493266, 0.0002090216) (0.0001348751, 0.00020863354) (0.00013479856, 0.00020824877) (0.00013470324, 0.00020786823) (0.00013458936, 0.00020749281) (0.0001344572, 0.00020712344) (0.00013430707, 0.000206761) (0.00013413934, 0.00020640636) (0.00013395441, 0.00020606038) (0.00013375272, 0.00020572389) (0.00013353477, 0.0002053977) (0.00013330107, 0.00020508259) (0.0001330522, 0.00020477934) (0.00013278874, 0.00020448866) (0.00013251134, 0.00020421126) (0.00013222066, 0.0002039478) (0.00013191741, 0.00020369893) (0.0001316023, 0.00020346523) (0.00013127611, 0.00020324728) (0.00013093962, 0.00020304559) (0.00013059364, 0.00020286066) (0.000130239, 0.00020269293) (0.00012987656, 0.0002025428) (0.00012950719, 0.00020241064) (0.00012913177, 0.00020229676) (0.00012875123, 0.00020220144) (0.00012836646, 0.0002021249) (0.0001279784, 0.00020206734) (0.00012758798, 0.00020202889) (0.00012709806, 0.00020200482) (0.00012690182, 0.000202) (-0.00012690182, 0.000202) (-0.00012709806, 0.00020200482) (-0.00012758798, 0.00020202889) (-0.0001279784, 0.00020206734) (-0.00012836646, 0.0002021249) (-0.00012875123, 0.00020220144) (-0.00012913177, 0.00020229676) (-0.00012950719, 0.00020241064) (-0.00012987656, 0.0002025428) (-0.000130239, 0.00020269293) (-0.00013059364, 0.00020286066) (-0.00013093962, 0.00020304559) (-0.00013127611, 0.00020324728) (-0.0001316023, 0.00020346523) (-0.00013191741, 0.00020369893) (-0.00013222066, 0.0002039478) (-0.00013251134, 0.00020421126) (-0.00013278874, 0.00020448866) (-0.0001330522, 0.00020477934) (-0.00013330107, 0.00020508259) (-0.00013353477, 0.0002053977) (-0.00013375272, 0.00020572389) (-0.00013395441, 0.00020606038) (-0.00013413934, 0.00020640636) (-0.00013430707, 0.000206761) (-0.0001344572, 0.00020712344) (-0.00013458936, 0.00020749281) (-0.00013470324, 0.00020786823) (-0.00013479856, 0.00020824877) (-0.0001348751, 0.00020863354) (-0.00013493266, 0.0002090216) (-0.00013497111, 0.00020941201) (-0.00013499518, 0.00020990194) (-0.000135, 0.00021009818) (-0.000135, 0.00036690182) (-0.00013499518, 0.00036709806) (-0.00013497111, 0.00036758799) (-0.00013493266, 0.0003679784) (-0.0001348751, 0.00036836646) (-0.00013479856, 0.00036875123) (-0.00013470324, 0.00036913177) (-0.00013458936, 0.00036950719) (-0.0001344572, 0.00036987656) (-0.00013430707, 0.000370239) (-0.00013413934, 0.00037059364) (-0.00013395441, 0.00037093962) (-0.00013375272, 0.00037127611) (-0.00013353477, 0.0003716023) (-0.00013330107, 0.0003719174) (-0.0001330522, 0.00037222066) (-0.00013278874, 0.00037251134) (-0.00013251134, 0.00037278874) (-0.00013222066, 0.0003730522) (-0.00013191741, 0.00037330107) (-0.0001316023, 0.00037353477) (-0.00013127611, 0.00037375272) (-0.00013093962, 0.00037395441) (-0.00013059364, 0.00037413934) (-0.000130239, 0.00037430707) (-0.00012987656, 0.0003744572) (-0.00012950719, 0.00037458936) (-0.00012913177, 0.00037470324) (-0.00012875123, 0.00037479856) (-0.00012836646, 0.0003748751) (-0.0001279784, 0.00037493266) (-0.00012758798, 0.00037497111) (-0.00012709806, 0.00037499518) (-0.00012690182, 0.000375) (-1.909818e-05, 0.000375) (-1.8901939e-05, 0.00037499518) (-1.8412015e-05, 0.00037497111) (-1.80216e-05, 0.00037493266) (-1.7633541e-05, 0.0003748751) (-1.7248774e-05, 0.00037479856) (-1.6868226e-05, 0.00037470324) (-1.6492814e-05, 0.00037458936) (-1.6123441e-05, 0.0003744572) (-1.5760999e-05, 0.00037430707) (-1.540636e-05, 0.00037413934) (-1.5060378e-05, 0.00037395441) (-1.4723887e-05, 0.00037375272) (-1.4397697e-05, 0.00037353477) (-1.4082595e-05, 0.00037330107) (-1.3779339e-05, 0.0003730522) (-1.348866e-05, 0.00037278874) (-1.3211259e-05, 0.00037251134) (-1.2947803e-05, 0.00037222066) (-1.2698928e-05, 0.0003719174) (-1.2465232e-05, 0.0003716023) (-1.2247279e-05, 0.00037127611) (-1.2045594e-05, 0.00037093962) (-1.1860663e-05, 0.00037059364) (-1.1692931e-05, 0.000370239) (-1.1542802e-05, 0.00036987656) (-1.1410639e-05, 0.00036950719) (-1.1296759e-05, 0.00036913177) (-1.1201436e-05, 0.00036875123) (-1.1124902e-05, 0.00036836646) (-1.1067338e-05, 0.0003679784) (-1.1028886e-05, 0.00036758799) (-1.1004817e-05, 0.00036709806) (-1.1e-05, 0.00036690182) (-1.1e-05, 0.00031909818) (-1.1004817e-05, 0.00031890194) (-1.1028886e-05, 0.00031841202) (-1.1067338e-05, 0.0003180216) (-1.1124902e-05, 0.00031763354) (-1.1201436e-05, 0.00031724877) (-1.1296759e-05, 0.00031686823) (-1.1410639e-05, 0.00031649281) (-1.1542802e-05, 0.00031612344) (-1.1692931e-05, 0.000315761) (-1.1860663e-05, 0.00031540636) (-1.2045594e-05, 0.00031506038) (-1.2247279e-05, 0.00031472389) (-1.2465232e-05, 0.0003143977) (-1.2698928e-05, 0.00031408259) (-1.2947803e-05, 0.00031377934) (-1.3211259e-05, 0.00031348866) (-1.348866e-05, 0.00031321126) (-1.3779339e-05, 0.0003129478) (-1.4082595e-05, 0.00031269893) (-1.4397697e-05, 0.00031246523) (-1.4723887e-05, 0.00031224728) (-1.5060378e-05, 0.00031204559) (-1.540636e-05, 0.00031186066) (-1.5760999e-05, 0.00031169293) (-1.6123441e-05, 0.0003115428) (-1.6492814e-05, 0.00031141064) (-1.6868226e-05, 0.00031129676)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, closed, covered)
  pocket_cp = polyline(z=0, xy: (0.000135, 0.00019) (-0.000135, 0.00019) (-0.00013617621, 0.00019005778) (-0.00013734108, 0.00019023058) (-0.00013848342, 0.00019051672) (-0.0001395922, 0.00019091345) (-0.00014065676, 0.00019141694) (-0.00014166684, 0.00019202237) (-0.00014261272, 0.00019272388) (-0.00014348528, 0.00019351472) (-0.00014427613, 0.00019438728) (-0.00014497764, 0.00019533316) (-0.00014558305, 0.00019634324) (-0.00014608655, 0.0001974078) (-0.00014648328, 0.00019851658) (-0.00014676942, 0.00019965892) (-0.00014694222, 0.00020082379) (-0.000147, 0.000202) (-0.000147, 0.000375) (-0.00014694222, 0.00037617621) (-0.00014676942, 0.00037734108) (-0.00014648328, 0.00037848342) (-0.00014608655, 0.0003795922) (-0.00014558305, 0.00038065676) (-0.00014497764, 0.00038166684) (-0.00014427613, 0.00038261272) (-0.00014348528, 0.00038348528) (-0.00014261272, 0.00038427613) (-0.00014166684, 0.00038497764) (-0.00014065676, 0.00038558305) (-0.0001395922, 0.00038608655) (-0.00013848342, 0.00038648328) (-0.00013734108, 0.00038676942) (-0.00013617621, 0.00038694222) (-0.000135, 0.000387) (0.000135, 0.000387) (0.00013617621, 0.00038694222) (0.00013734108, 0.00038676942) (0.00013848342, 0.00038648328) (0.0001395922, 0.00038608655) (0.00014065676, 0.00038558305) (0.00014166684, 0.00038497764) (0.00014261272, 0.00038427613) (0.00014348528, 0.00038348528) (0.00014427613, 0.00038261272) (0.00014497764, 0.00038166684) (0.00014558305, 0.00038065676) (0.00014608655, 0.0003795922) (0.00014648328, 0.00037848342) (0.00014676942, 0.00037734108) (0.00014694222, 0.00037617621) (0.000147, 0.000375) (0.000147, 0.000202) (0.00014694222, 0.00020082379) (0.00014676942, 0.00019965892) (0.00014648328, 0.00019851658) (0.00014608655, 0.0001974078) (0.00014558305, 0.00019634324) (0.00014497764, 0.00019533316) (0.00014427613, 0.00019438728) (0.00014348528, 0.00019351472) (0.00014261272, 0.00019272388) (0.00014166684, 0.00019202237) (0.00014065676, 0.00019141694) (0.0001395922, 0.00019091345) (0.00013848342, 0.00019051672) (0.00013734108, 0.00019023058) (0.00013617621, 0.00019005778) (0.000135, 0.00019), closed, covered)
  tap_trace_jf = polyline(z=0, xy: (-5e-06, 0.001465) (-5e-06, 0.001765) (5e-06, 0.001765) (5e-06, 0.00162) (7.55e-05, 0.00162) (7.55e-05, 0.00161) (5e-06, 0.00161) (5e-06, 0.001465) (-5e-06, 0.001465), closed, covered)
  tap_cut_jf = polyline(z=0, xy: (-1.1e-05, 0.001465) (-1.1e-05, 0.001765) (1.1e-05, 0.001765) (1.1e-05, 0.001626) (7.55e-05, 0.001626) (7.55e-05, 0.001604) (1.1e-05, 0.001604) (1.1e-05, 0.001465) (-1.1e-05, 0.001465), closed, covered)
  tap_trace_jr = polyline(z=0, xy: (0.0001745, 0.00162) (0.000245, 0.00162) (0.000245, 0.001765) (0.000255, 0.001765) (0.000255, 0.001465) (0.000245, 0.001465) (0.000245, 0.00161) (0.0001745, 0.00161) (0.0001745, 0.00162), closed, covered)
  tap_cut_jr = polyline(z=0, xy: (0.0001745, 0.001626) (0.000239, 0.001626) (0.000239, 0.001765) (0.000261, 0.001765) (0.000261, 0.001465) (0.000239, 0.001465) (0.000239, 0.001604) (0.0001745, 0.001604) (0.0001745, 0.001626), closed, covered)
  head_a_cj = polyline(z=0, xy: (0.0001075, 0.001596) (0.00010730397, 0.0015960096) (0.00010710982, 0.0015960384) (0.00010691943, 0.0015960861) (0.00010673463, 0.0015961522) (0.00010655721, 0.0015962362) (0.00010638886, 0.0015963371) (0.00010623121, 0.001596454) (0.00010608579, 0.0015965858) (0.00010595398, 0.0015967312) (0.00010583706, 0.0015968889) (0.00010573616, 0.0015970572) (0.00010565224, 0.0015972346) (0.00010558612, 0.0015974194) (0.00010553843, 0.0015976098) (0.00010550963, 0.001597804) (0.0001055, 0.001598) (0.0001055, 0.001632) (0.00010550963, 0.001632196) (0.00010553843, 0.0016323902) (0.00010558612, 0.0016325806) (0.00010565224, 0.0016327654) (0.00010573616, 0.0016329428) (0.00010583706, 0.0016331111) (0.00010595398, 0.0016332688) (0.00010608579, 0.0016334142) (0.00010623121, 0.001633546) (0.00010638886, 0.0016336629) (0.00010655721, 0.0016337638) (0.00010673463, 0.0016338478) (0.00010691943, 0.0016339139) (0.00010710982, 0.0016339616) (0.00010730397, 0.0016339904) (0.0001075, 0.001634) (0.0001185, 0.001634) (0.00011869603, 0.0016339904) (0.00011889018, 0.0016339616) (0.00011908057, 0.0016339139) (0.00011926537, 0.0016338478) (0.00011944279, 0.0016337638) (0.00011961114, 0.0016336629) (0.00011976879, 0.001633546) (0.00011991421, 0.0016334142) (0.00012004602, 0.0016332688) (0.00012016294, 0.0016331111) (0.00012026384, 0.0016329428) (0.00012034776, 0.0016327654) (0.00012041388, 0.0016325806) (0.00012046157, 0.0016323902) (0.00012049037, 0.001632196) (0.0001205, 0.001632) (0.0001205, 0.001598) (0.00012049037, 0.001597804) (0.00012046157, 0.0015976098) (0.00012041388, 0.0015974194) (0.00012034776, 0.0015972346) (0.00012026384, 0.0015970572) (0.00012016294, 0.0015968889) (0.00012004602, 0.0015967312) (0.00011991421, 0.0015965858) (0.00011976879, 0.001596454) (0.00011961114, 0.0015963371) (0.00011944279, 0.0015962362) (0.00011926537, 0.0015961522) (0.00011908057, 0.0015960861) (0.00011889018, 0.0015960384) (0.00011869603, 0.0015960096) (0.0001185, 0.001596) (0.0001075, 0.001596), closed, covered)
  head_b_cj = polyline(z=0, xy: (0.0001315, 0.001596) (0.00013130397, 0.0015960096) (0.00013110982, 0.0015960384) (0.00013091943, 0.0015960861) (0.00013073463, 0.0015961522) (0.00013055721, 0.0015962362) (0.00013038886, 0.0015963371) (0.00013023121, 0.001596454) (0.00013008579, 0.0015965858) (0.00012995398, 0.0015967312) (0.00012983706, 0.0015968889) (0.00012973616, 0.0015970572) (0.00012965224, 0.0015972346) (0.00012958612, 0.0015974194) (0.00012953843, 0.0015976098) (0.00012950963, 0.001597804) (0.0001295, 0.001598) (0.0001295, 0.001632) (0.00012950963, 0.001632196) (0.00012953843, 0.0016323902) (0.00012958612, 0.0016325806) (0.00012965224, 0.0016327654) (0.00012973616, 0.0016329428) (0.00012983706, 0.0016331111) (0.00012995398, 0.0016332688) (0.00013008579, 0.0016334142) (0.00013023121, 0.001633546) (0.00013038886, 0.0016336629) (0.00013055721, 0.0016337638) (0.00013073463, 0.0016338478) (0.00013091943, 0.0016339139) (0.00013110982, 0.0016339616) (0.00013130397, 0.0016339904) (0.0001315, 0.001634) (0.0001425, 0.001634) (0.00014269603, 0.0016339904) (0.00014289018, 0.0016339616) (0.00014308057, 0.0016339139) (0.00014326537, 0.0016338478) (0.00014344279, 0.0016337638) (0.00014361114, 0.0016336629) (0.00014376879, 0.001633546) (0.00014391421, 0.0016334142) (0.00014404602, 0.0016332688) (0.00014416294, 0.0016331111) (0.00014426384, 0.0016329428) (0.00014434776, 0.0016327654) (0.00014441388, 0.0016325806) (0.00014446157, 0.0016323902) (0.00014449037, 0.001632196) (0.0001445, 0.001632) (0.0001445, 0.001598) (0.00014449037, 0.001597804) (0.00014446157, 0.0015976098) (0.00014441388, 0.0015974194) (0.00014434776, 0.0015972346) (0.00014426384, 0.0015970572) (0.00014416294, 0.0015968889) (0.00014404602, 0.0015967312) (0.00014391421, 0.0015965858) (0.00014376879, 0.001596454) (0.00014361114, 0.0015963371) (0.00014344279, 0.0015962362) (0.00014326537, 0.0015961522) (0.00014308057, 0.0015960861) (0.00014289018, 0.0015960384) (0.00014269603, 0.0015960096) (0.0001425, 0.001596) (0.0001315, 0.001596), closed, covered)
  pocket_cj = polyline(z=0, xy: (9.75e-05, 0.001586) (9.7303966e-05, 0.0015860096) (9.7109819e-05, 0.0015860384) (9.6919431e-05, 0.0015860861) (9.6734633e-05, 0.0015861522) (9.6557207e-05, 0.0015862362) (9.638886e-05, 0.0015863371) (9.6231213e-05, 0.001586454) (9.6085786e-05, 0.0015865858) (9.5953979e-05, 0.0015867312) (9.5837061e-05, 0.0015868889) (9.5736157e-05, 0.0015870572) (9.5652241e-05, 0.0015872346) (9.5586119e-05, 0.0015874194) (9.5538429e-05, 0.0015876098) (9.5509631e-05, 0.001587804) (9.55e-05, 0.001588) (9.55e-05, 0.001642) (9.5509631e-05, 0.001642196) (9.5538429e-05, 0.0016423902) (9.5586119e-05, 0.0016425806) (9.5652241e-05, 0.0016427654) (9.5736157e-05, 0.0016429428) (9.5837061e-05, 0.0016431111) (9.5953979e-05, 0.0016432688) (9.6085786e-05, 0.0016434142) (9.6231213e-05, 0.001643546) (9.638886e-05, 0.0016436629) (9.6557207e-05, 0.0016437638) (9.6734633e-05, 0.0016438478) (9.6919431e-05, 0.0016439139) (9.7109819e-05, 0.0016439616) (9.7303966e-05, 0.0016439904) (9.75e-05, 0.001644) (0.0001525, 0.001644) (0.00015269603, 0.0016439904) (0.00015289018, 0.0016439616) (0.00015308057, 0.0016439139) (0.00015326537, 0.0016438478) (0.00015344279, 0.0016437638) (0.00015361114, 0.0016436629) (0.00015376879, 0.001643546) (0.00015391421, 0.0016434142) (0.00015404602, 0.0016432688) (0.00015416294, 0.0016431111) (0.00015426384, 0.0016429428) (0.00015434776, 0.0016427654) (0.00015441388, 0.0016425806) (0.00015446157, 0.0016423902) (0.00015449037, 0.001642196) (0.0001545, 0.001642) (0.0001545, 0.001588) (0.00015449037, 0.001587804) (0.00015446157, 0.0015876098) (0.00015441388, 0.0015874194) (0.00015434776, 0.0015872346) (0.00015426384, 0.0015870572) (0.00015416294, 0.0015868889) (0.00015404602, 0.0015867312) (0.00015391421, 0.0015865858) (0.00015376879, 0.001586454) (0.00015361114, 0.0015863371) (0.00015344279, 0.0015862362) (0.00015326537, 0.0015861522) (0.00015308057, 0.0015860861) (0.00015289018, 0.0015860384) (0.00015269603, 0.0015860096) (0.0001525, 0.001586) (9.75e-05, 0.001586), closed, covered)
  open_to_ground_readout_open = rectangle(corner=(0.000239, 0.002915, 0), x_size=2.2e-05, y_size=6e-06)
  endcap_feed_in_start = rectangle(corner=(-0.001626, -1.1e-05, 0), x_size=6e-06, y_size=2.2e-05)
  endcap_feed_out_end = rectangle(corner=(0.00162, -1.1e-05, 0), x_size=6e-06, y_size=2.2e-05)
  ground_main_plane = rectangle(corner=(-0.00182, -0.000347, 0), x_size=0.00364, y_size=0.003468)
  main [silicon_eps11p45] = box(corner=(-0.00182, -0.000347, -0.0005), size=(0.00364, 0.003468, 0.0005))
  sample_holder [vacuum] = box(corner=(-0.00182, -0.000347, -0.00165), size=(0.00364, 0.003468, 0.00254))
  ground_main_plane.subtract(pocket_cp, tap_cut_jr, pocket_cj, tap_cut_n0, cut_stub_p, open_to_ground_readout_open, cut_stub_r, endcap_feed_in_start, lead_a_sub_cp, lead_b_sub_cj, cut_filter_tail, endcap_feed_out_end, cut_stub_f, pocket_cin, cut_feed_in, lead_b_sub_cin, lead_b_sub_cp, cut_feed_mid, lead_a_sub_cj, lead_a_sub_cin, cut_res_tail, tap_cut_jf, cut_feed_out, cut_res_open_run, cut_feed_jf)
  Port_feed_in_start = rectangle(corner=(-0.001626, -5e-06, 0), x_size=6e-06, y_size=1e-05)
  voltage_line_Port_feed_in_start = polyline((-0.00162, 0, 0) (-0.001626, 0, 0))
  Port_feed_out_end = rectangle(corner=(0.00162, -5e-06, 0), x_size=6e-06, y_size=1e-05)
  voltage_line_Port_feed_out_end = polyline((0.00162, 0, 0) (0.001626, 0, 0))
  g_wb_13 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=5.325e-05 YPadPos=0.001585 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_14 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00019675 YPadPos=0.001585 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
boundaries and excitations:
  RLCBoundary_feed_in_start: Lumped RLC Objects=Port_feed_in_start CurrentLine{middle of Port_feed_in_start.edge(x at corner) -> middle of Port_feed_in_start.edge(x opposite corner)} RLC_Type=Parallel Resistance=50ohm
  RLCBoundary_feed_out_end: Lumped RLC Objects=Port_feed_out_end CurrentLine{middle of Port_feed_out_end.edge(x at corner) -> middle of Port_feed_out_end.edge(x opposite corner)} RLC_Type=Parallel Resistance=50ohm
  PerfE: Perfect E Objects=[lead_a_cin, lead_b_cin, lead_a_cp, lead_b_cp, trace_feed_in, trace_feed_mid, trace_feed_out, trace_stub_p, lead_a_cj, lead_b_cj, trace_stub_f, trace_stub_r, trace_feed_jf, trace_res_open_run, trace_filter_tail, trace_res_tail, plate_cin, frame_cin, tap_trace_n0, plate_cp, frame_cp, tap_trace_jf, tap_trace_jr, head_a_cj, head_b_cj, ground_main_plane]
mesh:
  port_mesh: LengthBased Objects=[Port_feed_in_start, Port_feed_out_end] MaxLength=7um
  cpw_line_mesh: LengthBased Objects=[lead_a_cin, lead_b_cin, trace_feed_in, trace_feed_mid, trace_feed_out, trace_stub_p, trace_stub_f, trace_stub_r, trace_feed_jf, trace_res_open_run, trace_filter_tail, trace_res_tail, plate_cin, frame_cin, tap_trace_n0, tap_trace_jf, tap_trace_jr] MaxLength=20um
  cap_mesh: LengthBased Objects=[lead_a_cp, lead_b_cp, lead_a_cj, lead_b_cj, plate_cp, frame_cp, head_a_cj, head_b_cj] MaxLength=9um
setups:
  Setup: HfssEigen MinimumFrequency=5.95GHz NumModes=2 MaxDeltaFreq=0.1 ConvergeOnRealFreq=true MaximumPasses=15 MinimumPasses=3 MinimumConvergedPasses=2 PercentRefinement=20 BasisOrder=1
source amplitudes:
  #-10:1: 1 0deg
  #-10:2: 0 0deg
reports:
  Freq. vs. pass: re(Mode(1)), re(Mode(2)) vs Pass on Setup : AdaptivePass

design P250g9_straps_m9um_1837_hfss (HFSS, Eigenmode, model units mm)
geometry:
  lead_a_cin_path = polyline((-0.000740499, 0, 0) (-0.0007925, 0, 0))
  lead_a_cin = polyline((-0.000740499, -5e-06, 0) (-0.000740499, 5e-06, 0))
  lead_a_cin.sweep_along_path(lead_a_cin_path)
  lead_a_sub_cin_path = polyline((-0.000740499, 0, 0) (-0.0007925, 0, 0))
  lead_a_sub_cin = polyline((-0.000740499, -1.1e-05, 0) (-0.000740499, 1.1e-05, 0))
  lead_a_sub_cin.sweep_along_path(lead_a_sub_cin_path)
  lead_b_cin_path = polyline((-0.000639501, 0, 0) (-0.0005275, 0, 0))
  lead_b_cin = polyline((-0.000639501, 5e-06, 0) (-0.000639501, -5e-06, 0))
  lead_b_cin.sweep_along_path(lead_b_cin_path)
  lead_b_sub_cin_path = polyline((-0.000639501, 0, 0) (-0.0005275, 0, 0))
  lead_b_sub_cin = polyline((-0.000639501, 1.1e-05, 0) (-0.000639501, -1.1e-05, 0))
  lead_b_sub_cin.sweep_along_path(lead_b_sub_cin_path)
  lead_a_cp_path = polyline((0, 0.000202001, 0) (0, 0.00015, 0))
  lead_a_cp = polyline((5e-06, 0.000202001, 0) (-5e-06, 0.000202001, 0))
  lead_a_cp.sweep_along_path(lead_a_cp_path)
  lead_a_sub_cp_path = polyline((0, 0.000202001, 0) (0, 0.00015, 0))
  lead_a_sub_cp = polyline((1.1e-05, 0.000202001, 0) (-1.1e-05, 0.000202001, 0))
  lead_a_sub_cp.sweep_along_path(lead_a_sub_cp_path)
  lead_b_cp_path = polyline((0, 0.000302999, 0) (0, 0.000415, 0))
  lead_b_cp = polyline((-5e-06, 0.000302999, 0) (5e-06, 0.000302999, 0))
  lead_b_cp.sweep_along_path(lead_b_cp_path)
  lead_b_sub_cp_path = polyline((0, 0.000302999, 0) (0, 0.000415, 0))
  lead_b_sub_cp = polyline((-1.1e-05, 0.000302999, 0) (1.1e-05, 0.000302999, 0))
  lead_b_sub_cp.sweep_along_path(lead_b_sub_cp_path)
  trace_feed_in_path = polyline((-0.00162, 0, 0) (-0.0007925, 0, 0))
  trace_feed_in = polyline((-0.00162, 5e-06, 0) (-0.00162, -5e-06, 0))
  trace_feed_in.sweep_along_path(trace_feed_in_path)
  cut_feed_in_path = polyline((-0.00162, 0, 0) (-0.0007925, 0, 0))
  cut_feed_in = polyline((-0.00162, 1.1e-05, 0) (-0.00162, -1.1e-05, 0))
  cut_feed_in.sweep_along_path(cut_feed_in_path)
  trace_feed_mid_path = polyline((-0.0005275, 0, 0) (-0.00015, 0, 0))
  trace_feed_mid = polyline((-0.0005275, 5e-06, 0) (-0.0005275, -5e-06, 0))
  trace_feed_mid.sweep_along_path(trace_feed_mid_path)
  cut_feed_mid_path = polyline((-0.0005275, 0, 0) (-0.00015, 0, 0))
  cut_feed_mid = polyline((-0.0005275, 1.1e-05, 0) (-0.0005275, -1.1e-05, 0))
  cut_feed_mid.sweep_along_path(cut_feed_mid_path)
  trace_feed_out_path = polyline((0.00015, 0, 0) (0.00162, 0, 0))
  trace_feed_out = polyline((0.00015, 5e-06, 0) (0.00015, -5e-06, 0))
  trace_feed_out.sweep_along_path(trace_feed_out_path)
  cut_feed_out_path = polyline((0.00015, 0, 0) (0.00162, 0, 0))
  cut_feed_out = polyline((0.00015, 1.1e-05, 0) (0.00015, -1.1e-05, 0))
  cut_feed_out.sweep_along_path(cut_feed_out_path)
  trace_stub_p_path = polyline((0, 0.0001, 0) (0, 0.00015, 0))
  trace_stub_p = polyline((-5e-06, 0.0001, 0) (5e-06, 0.0001, 0))
  trace_stub_p.sweep_along_path(trace_stub_p_path)
  cut_stub_p_path = polyline((0, 0.0001, 0) (0, 0.00015, 0))
  cut_stub_p = polyline((-1.1e-05, 0.0001, 0) (1.1e-05, 0.0001, 0))
  cut_stub_p.sweep_along_path(cut_stub_p_path)
  lead_a_cj_path = polyline((0.000105501, 0.001615, 0) (9.55e-05, 0.001615, 0))
  lead_a_cj = polyline((0.000105501, 0.00161, 0) (0.000105501, 0.00162, 0))
  lead_a_cj.sweep_along_path(lead_a_cj_path)
  lead_a_sub_cj_path = polyline((0.000105501, 0.001615, 0) (9.55e-05, 0.001615, 0))
  lead_a_sub_cj = polyline((0.000105501, 0.001604, 0) (0.000105501, 0.001626, 0))
  lead_a_sub_cj.sweep_along_path(lead_a_sub_cj_path)
  lead_b_cj_path = polyline((0.000144499, 0.001615, 0) (0.0001545, 0.001615, 0))
  lead_b_cj = polyline((0.000144499, 0.00162, 0) (0.000144499, 0.00161, 0))
  lead_b_cj.sweep_along_path(lead_b_cj_path)
  lead_b_sub_cj_path = polyline((0.000144499, 0.001615, 0) (0.0001545, 0.001615, 0))
  lead_b_sub_cj = polyline((0.000144499, 0.001626, 0) (0.000144499, 0.001604, 0))
  lead_b_sub_cj.sweep_along_path(lead_b_sub_cj_path)
  trace_stub_f_path = polyline((7.55e-05, 0.001615, 0) (9.55e-05, 0.001615, 0))
  trace_stub_f = polyline((7.55e-05, 0.00162, 0) (7.55e-05, 0.00161, 0))
  trace_stub_f.sweep_along_path(trace_stub_f_path)
  cut_stub_f_path = polyline((7.55e-05, 0.001615, 0) (9.55e-05, 0.001615, 0))
  cut_stub_f = polyline((7.55e-05, 0.001626, 0) (7.55e-05, 0.001604, 0))
  cut_stub_f.sweep_along_path(cut_stub_f_path)
  trace_stub_r_path = polyline((0.0001545, 0.001615, 0) (0.0001745, 0.001615, 0))
  trace_stub_r = polyline((0.0001545, 0.00162, 0) (0.0001545, 0.00161, 0))
  trace_stub_r.sweep_along_path(trace_stub_r_path)
  cut_stub_r_path = polyline((0.0001545, 0.001615, 0) (0.0001745, 0.001615, 0))
  cut_stub_r = polyline((0.0001545, 0.001626, 0) (0.0001545, 0.001604, 0))
  cut_stub_r.sweep_along_path(cut_stub_r_path)
  trace_feed_jf_path = polyline((0, 0.000415, 0) (0, 0.001465, 0))
  trace_feed_jf = polyline((-5e-06, 0.000415, 0) (5e-06, 0.000415, 0))
  trace_feed_jf.sweep_along_path(trace_feed_jf_path)
  cut_feed_jf_path = polyline((0, 0.000415, 0) (0, 0.001465, 0))
  cut_feed_jf = polyline((-1.1e-05, 0.000415, 0) (1.1e-05, 0.000415, 0))
  cut_feed_jf.sweep_along_path(cut_feed_jf_path)
  trace_res_open_run_path = polyline((0.00025, 0.001765, 0) (0.00025, 0.002915, 0))
  trace_res_open_run = polyline((0.000245, 0.001765, 0) (0.000255, 0.001765, 0))
  trace_res_open_run.sweep_along_path(trace_res_open_run_path)
  cut_res_open_run_path = polyline((0.00025, 0.001765, 0) (0.00025, 0.002915, 0))
  cut_res_open_run = polyline((0.000239, 0.001765, 0) (0.000261, 0.001765, 0))
  cut_res_open_run.sweep_along_path(cut_res_open_run_path)
  trace_filter_tail_path = polyline(z=0, xy: (0, 0.001765) (0, 0.002285) (-0.00051923387, 0.002285) (-0.00051923387, 0.002055) (-0.00025, 0.002055) (-0.00025, 0.001825) (-0.00051923387, 0.001825) (-0.00051923387, 0.001595) (-0.00025, 0.001595) (-0.00025, 0.001365) (-0.00051923387, 0.001365) (-0.00051923387, 0.001135))
  trace_filter_tail_path.fillet(Vertices=trace_filter_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  trace_filter_tail = polyline((-5e-06, 0.001765, 0) (5e-06, 0.001765, 0))
  trace_filter_tail.sweep_along_path(trace_filter_tail_path)
  cut_filter_tail_path = polyline(z=0, xy: (0, 0.001765) (0, 0.002285) (-0.00051923387, 0.002285) (-0.00051923387, 0.002055) (-0.00025, 0.002055) (-0.00025, 0.001825) (-0.00051923387, 0.001825) (-0.00051923387, 0.001595) (-0.00025, 0.001595) (-0.00025, 0.001365) (-0.00051923387, 0.001365) (-0.00051923387, 0.001135))
  cut_filter_tail_path.fillet(Vertices=cut_filter_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  cut_filter_tail = polyline((-1.1e-05, 0.001765, 0) (1.1e-05, 0.001765, 0))
  cut_filter_tail.sweep_along_path(cut_filter_tail_path)
  trace_res_tail_path = polyline(z=0, xy: (0.00025, 0.001465) (0.00025, 0.000765) (0.00077617693, 0.000765) (0.00077617693, 0.000995) (0.0005, 0.000995) (0.0005, 0.001225) (0.00077617693, 0.001225) (0.00077617693, 0.001455) (0.0005, 0.001455) (0.0005, 0.001685) (0.00077617693, 0.001685) (0.00077617693, 0.001906))
  trace_res_tail_path.fillet(Vertices=trace_res_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  trace_res_tail = polyline((0.000255, 0.001465, 0) (0.000245, 0.001465, 0))
  trace_res_tail.sweep_along_path(trace_res_tail_path)
  cut_res_tail_path = polyline(z=0, xy: (0.00025, 0.001465) (0.00025, 0.000765) (0.00077617693, 0.000765) (0.00077617693, 0.000995) (0.0005, 0.000995) (0.0005, 0.001225) (0.00077617693, 0.001225) (0.00077617693, 0.001455) (0.0005, 0.001455) (0.0005, 0.001685) (0.00077617693, 0.001685) (0.00077617693, 0.001906))
  cut_res_tail_path.fillet(Vertices=cut_res_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  cut_res_tail = polyline((0.000261, 0.001465, 0) (0.000239, 0.001465, 0))
  cut_res_tail.sweep_along_path(cut_res_tail_path)
  g_wb [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.0013441667 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_1 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.0010683333 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_2 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.0005175 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_3 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000885 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_4 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.0012525 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_5 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=5.5e-05 YPadPos=0.000765 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_6 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=5.5e-05 YPadPos=0.001115 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_7 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000305 YPadPos=0.0021483333 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_8 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000305 YPadPos=0.0025316667 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_9 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=5.5e-05 YPadPos=0.002025 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_10 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00025961694 YPadPos=0.00234 ZPadPos=0 XDir=0 YDir=-1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_11 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000195 YPadPos=0.001115 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_12 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00051308846 YPadPos=0.00071 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  plate_cin = polyline(z=0, xy: (-0.0006725, -7e-05) (-0.00067328414, -6.9961478e-05) (-0.00067406072, -6.9846282e-05) (-0.00067482228, -6.9655523e-05) (-0.00067556147, -6.9391036e-05) (-0.00067627117, -6.905537e-05) (-0.00067694456, -6.8651757e-05) (-0.00067757515, -6.8184084e-05) (-0.00067815685, -6.7656854e-05) (-0.00067868408, -6.7075146e-05) (-0.00067915176, -6.6444562e-05) (-0.00067955537, -6.5771174e-05) (-0.00067989104, -6.5061467e-05) (-0.00068015552, -6.4322277e-05) (-0.00068034628, -6.3560723e-05) (-0.00068046148, -6.2784137e-05) (-0.0006805, -6.2e-05) (-0.0006805, 6.2e-05) (-0.00068046148, 6.2784137e-05) (-0.00068034628, 6.3560723e-05) (-0.00068015552, 6.4322277e-05) (-0.00067989104, 6.5061467e-05) (-0.00067955537, 6.5771174e-05) (-0.00067915176, 6.6444562e-05) (-0.00067868408, 6.7075146e-05) (-0.00067815685, 6.7656854e-05) (-0.00067757515, 6.8184084e-05) (-0.00067694456, 6.8651757e-05) (-0.00067627117, 6.905537e-05) (-0.00067556147, 6.9391036e-05) (-0.00067482228, 6.9655523e-05) (-0.00067406072, 6.9846282e-05) (-0.00067328414, 6.9961478e-05) (-0.0006725, 7e-05) (-0.0006475, 7e-05) (-0.00064671586, 6.9961478e-05) (-0.00064593928, 6.9846282e-05) (-0.00064517772, 6.9655523e-05) (-0.00064443853, 6.9391036e-05) (-0.00064372883, 6.905537e-05) (-0.00064305544, 6.8651757e-05) (-0.00064242485, 6.8184084e-05) (-0.00064184315, 6.7656854e-05) (-0.00064131592, 6.7075146e-05) (-0.00064084824, 6.6444562e-05) (-0.00064044463, 6.5771174e-05) (-0.00064010896, 6.5061467e-05) (-0.00063984448, 6.4322277e-05) (-0.00063965372, 6.3560723e-05) (-0.00063953852, 6.2784137e-05) (-0.0006395, 6.2e-05) (-0.0006395, -6.2e-05) (-0.00063953852, -6.2784137e-05) (-0.00063965372, -6.3560723e-05) (-0.00063984448, -6.4322277e-05) (-0.00064010896, -6.5061467e-05) (-0.00064044463, -6.5771174e-05) (-0.00064084824, -6.6444562e-05) (-0.00064131592, -6.7075146e-05) (-0.00064184315, -6.7656854e-05) (-0.00064242485, -6.8184084e-05) (-0.00064305544, -6.8651757e-05) (-0.00064372883, -6.905537e-05) (-0.00064443853, -6.9391036e-05) (-0.00064517772, -6.9655523e-05) (-0.00064593928, -6.9846282e-05) (-0.00064671586, -6.9961478e-05) (-0.0006475, -7e-05) (-0.0006725, -7e-05), closed, covered)
  frame_cin = polyline(z=0, xy: (-0.0006885, -7e-05) (-0.00068846148, -7.0784137e-05) (-0.00068834628, -7.1560723e-05) (-0.00068815552, -7.2322277e-05) (-0.00068789104, -7.3061467e-05) (-0.00068755537, -7.3771174e-05) (-0.00068715176, -7.4444562e-05) (-0.00068668408, -7.5075146e-05) (-0.00068615685, -7.5656854e-05) (-0.00068557515, -7.6184084e-05) (-0.00068494456, -7.6651757e-05) (-0.00068427117, -7.705537e-05) (-0.00068356147, -7.7391036e-05) (-0.00068282228, -7.7655523e-05) (-0.00068206072, -7.7846282e-05) (-0.00068128414, -7.7961478e-05) (-0.0006805, -7.8e-05) (-0.0006395, -7.8e-05) (-0.00063871586, -7.7961478e-05) (-0.00063793928, -7.7846282e-05) (-0.00063717772, -7.7655523e-05) (-0.00063643853, -7.7391036e-05) (-0.00063572883, -7.705537e-05) (-0.00063505544, -7.6651757e-05) (-0.00063442485, -7.6184084e-05) (-0.00063384315, -7.5656854e-05) (-0.00063331592, -7.5075146e-05) (-0.00063284824, -7.4444562e-05) (-0.00063244463, -7.3771174e-05) (-0.00063210896, -7.3061467e-05) (-0.00063184448, -7.2322277e-05) (-0.00063165372, -7.1560723e-05) (-0.00063153852, -7.0784137e-05) (-0.0006315, -7e-05) (-0.0006315, -1.909818e-05) (-0.00063149518, -1.8901939e-05) (-0.00063147111, -1.8412015e-05) (-0.00063143266, -1.80216e-05) (-0.0006313751, -1.7633541e-05) (-0.00063129856, -1.7248774e-05) (-0.00063120324, -1.6868226e-05) (-0.00063108936, -1.6492814e-05) (-0.0006309572, -1.6123441e-05) (-0.00063080707, -1.5760999e-05) (-0.00063063934, -1.540636e-05) (-0.00063045441, -1.5060378e-05) (-0.00063025272, -1.4723887e-05) (-0.00063003477, -1.4397697e-05) (-0.00062980107, -1.4082595e-05) (-0.0006295522, -1.3779339e-05) (-0.00062928874, -1.348866e-05) (-0.00062901134, -1.3211259e-05) (-0.00062872066, -1.2947803e-05) (-0.00062841741, -1.2698928e-05) (-0.0006281023, -1.2465232e-05) (-0.00062777611, -1.2247279e-05) (-0.00062743962, -1.2045594e-05) (-0.00062709364, -1.1860663e-05) (-0.000626739, -1.1692931e-05) (-0.00062637656, -1.1542802e-05) (-0.00062600719, -1.1410639e-05) (-0.00062563177, -1.1296759e-05) (-0.00062525123, -1.1201436e-05) (-0.00062486646, -1.1124902e-05) (-0.0006244784, -1.1067338e-05) (-0.00062408799, -1.1028886e-05) (-0.00062359806, -1.1004817e-05) (-0.00062340182, -1.1e-05) (-0.00057559818, -1.1e-05) (-0.00057540194, -1.1004817e-05) (-0.00057491201, -1.1028886e-05) (-0.0005745216, -1.1067338e-05) (-0.00057413354, -1.1124902e-05) (-0.00057374877, -1.1201436e-05) (-0.00057336823, -1.1296759e-05) (-0.00057299281, -1.1410639e-05) (-0.00057262344, -1.1542802e-05) (-0.000572261, -1.1692931e-05) (-0.00057190636, -1.1860663e-05) (-0.00057156038, -1.2045594e-05) (-0.00057122389, -1.2247279e-05) (-0.0005708977, -1.2465232e-05) (-0.0005705826, -1.2698928e-05) (-0.00057027934, -1.2947803e-05) (-0.00056998866, -1.3211259e-05) (-0.00056971126, -1.348866e-05) (-0.0005694478, -1.3779339e-05) (-0.00056919893, -1.4082595e-05) (-0.00056896523, -1.4397697e-05) (-0.00056874728, -1.4723887e-05) (-0.00056854559, -1.5060378e-05) (-0.00056836066, -1.540636e-05) (-0.00056819293, -1.5760999e-05) (-0.0005680428, -1.6123441e-05) (-0.00056791064, -1.6492814e-05) (-0.00056779676, -1.6868226e-05) (-0.00056770144, -1.7248774e-05) (-0.0005676249, -1.7633541e-05) (-0.00056756734, -1.80216e-05) (-0.00056752889, -1.8412015e-05) (-0.00056750482, -1.8901939e-05) (-0.0005675, -1.909818e-05) (-0.0005675, -0.00012690182) (-0.00056750482, -0.00012709806) (-0.00056752889, -0.00012758798) (-0.00056756734, -0.0001279784) (-0.0005676249, -0.00012836646) (-0.00056770144, -0.00012875123) (-0.00056779676, -0.00012913177) (-0.00056791064, -0.00012950719) (-0.0005680428, -0.00012987656) (-0.00056819293, -0.000130239) (-0.00056836066, -0.00013059364) (-0.00056854559, -0.00013093962) (-0.00056874728, -0.00013127611) (-0.00056896523, -0.0001316023) (-0.00056919893, -0.00013191741) (-0.0005694478, -0.00013222066) (-0.00056971126, -0.00013251134) (-0.00056998866, -0.00013278874) (-0.00057027934, -0.0001330522) (-0.0005705826, -0.00013330107) (-0.0005708977, -0.00013353477) (-0.00057122389, -0.00013375272) (-0.00057156038, -0.00013395441) (-0.00057190636, -0.00013413934) (-0.000572261, -0.00013430707) (-0.00057262344, -0.0001344572) (-0.00057299281, -0.00013458936) (-0.00057336823, -0.00013470324) (-0.00057374877, -0.00013479856) (-0.00057413354, -0.0001348751) (-0.0005745216, -0.00013493266) (-0.00057491201, -0.00013497111) (-0.00057540194, -0.00013499518) (-0.00057559818, -0.000135) (-0.00073240182, -0.000135) (-0.00073259806, -0.00013499518) (-0.00073308798, -0.00013497111) (-0.0007334784, -0.00013493266) (-0.00073386646, -0.0001348751) (-0.00073425123, -0.00013479856) (-0.00073463177, -0.00013470324) (-0.00073500719, -0.00013458936) (-0.00073537656, -0.0001344572) (-0.000735739, -0.00013430707) (-0.00073609364, -0.00013413934) (-0.00073643962, -0.00013395441) (-0.00073677611, -0.00013375272) (-0.0007371023, -0.00013353477) (-0.0007374174, -0.00013330107) (-0.00073772066, -0.0001330522) (-0.00073801134, -0.00013278874) (-0.00073828874, -0.00013251134) (-0.0007385522, -0.00013222066) (-0.00073880107, -0.00013191741) (-0.00073903477, -0.0001316023) (-0.00073925272, -0.00013127611) (-0.00073945441, -0.00013093962) (-0.00073963934, -0.00013059364) (-0.00073980707, -0.000130239) (-0.0007399572, -0.00012987656) (-0.00074008936, -0.00012950719) (-0.00074020324, -0.00012913177) (-0.00074029856, -0.00012875123) (-0.0007403751, -0.00012836646) (-0.00074043266, -0.0001279784) (-0.00074047111, -0.00012758798) (-0.00074049518, -0.00012709806) (-0.0007405, -0.00012690182) (-0.0007405, 0.00012690182) (-0.00074049518, 0.00012709806) (-0.00074047111, 0.00012758798) (-0.00074043266, 0.0001279784) (-0.0007403751, 0.00012836646) (-0.00074029856, 0.00012875123) (-0.00074020324, 0.00012913177) (-0.00074008936, 0.00012950719) (-0.0007399572, 0.00012987656) (-0.00073980707, 0.000130239) (-0.00073963934, 0.00013059364) (-0.00073945441, 0.00013093962) (-0.00073925272, 0.00013127611) (-0.00073903477, 0.0001316023) (-0.00073880107, 0.00013191741) (-0.0007385522, 0.00013222066) (-0.00073828874, 0.00013251134) (-0.00073801134, 0.00013278874) (-0.00073772066, 0.0001330522) (-0.0007374174, 0.00013330107) (-0.0007371023, 0.00013353477) (-0.00073677611, 0.00013375272) (-0.00073643962, 0.00013395441) (-0.00073609364, 0.00013413934) (-0.000735739, 0.00013430707) (-0.00073537656, 0.0001344572) (-0.00073500719, 0.00013458936) (-0.00073463177, 0.00013470324) (-0.00073425123, 0.00013479856) (-0.00073386646, 0.0001348751) (-0.0007334784, 0.00013493266) (-0.00073308798, 0.00013497111) (-0.00073259806, 0.00013499518) (-0.00073240182, 0.000135) (-0.00057559818, 0.000135) (-0.00057540194, 0.00013499518) (-0.00057491201, 0.00013497111) (-0.0005745216, 0.00013493266) (-0.00057413354, 0.0001348751) (-0.00057374877, 0.00013479856) (-0.00057336823, 0.00013470324) (-0.00057299281, 0.00013458936) (-0.00057262344, 0.0001344572) (-0.000572261, 0.00013430707) (-0.00057190636, 0.00013413934) (-0.00057156038, 0.00013395441) (-0.00057122389, 0.00013375272) (-0.0005708977, 0.00013353477) (-0.0005705826, 0.00013330107) (-0.00057027934, 0.0001330522) (-0.00056998866, 0.00013278874) (-0.00056971126, 0.00013251134) (-0.0005694478, 0.00013222066) (-0.00056919893, 0.00013191741) (-0.00056896523, 0.0001316023) (-0.00056874728, 0.00013127611) (-0.00056854559, 0.00013093962) (-0.00056836066, 0.00013059364) (-0.00056819293, 0.000130239) (-0.0005680428, 0.00012987656) (-0.00056791064, 0.00012950719) (-0.00056779676, 0.00012913177) (-0.00056770144, 0.00012875123) (-0.0005676249, 0.00012836646) (-0.00056756734, 0.0001279784) (-0.00056752889, 0.00012758798) (-0.00056750482, 0.00012709806) (-0.0005675, 0.00012690182) (-0.0005675, 1.909818e-05) (-0.00056750482, 1.8901939e-05) (-0.00056752889, 1.8412015e-05) (-0.00056756734, 1.80216e-05) (-0.0005676249, 1.7633541e-05) (-0.00056770144, 1.7248774e-05) (-0.00056779676, 1.6868226e-05) (-0.00056791064, 1.6492814e-05) (-0.0005680428, 1.6123441e-05) (-0.00056819293, 1.5760999e-05) (-0.00056836066, 1.540636e-05) (-0.00056854559, 1.5060378e-05) (-0.00056874728, 1.4723887e-05) (-0.00056896523, 1.4397697e-05) (-0.00056919893, 1.4082595e-05) (-0.0005694478, 1.3779339e-05) (-0.00056971126, 1.348866e-05) (-0.00056998866, 1.3211259e-05) (-0.00057027934, 1.2947803e-05) (-0.0005705826, 1.2698928e-05) (-0.0005708977, 1.2465232e-05) (-0.00057122389, 1.2247279e-05) (-0.00057156038, 1.2045594e-05) (-0.00057190636, 1.1860663e-05) (-0.000572261, 1.1692931e-05) (-0.00057262344, 1.1542802e-05) (-0.00057299281, 1.1410639e-05) (-0.00057336823, 1.1296759e-05) (-0.00057374877, 1.1201436e-05) (-0.00057413354, 1.1124902e-05) (-0.0005745216, 1.1067338e-05) (-0.00057491201, 1.1028886e-05) (-0.00057540194, 1.1004817e-05) (-0.00057559818, 1.1e-05) (-0.00062340182, 1.1e-05) (-0.00062359806, 1.1004817e-05) (-0.00062408799, 1.1028886e-05) (-0.0006244784, 1.1067338e-05) (-0.00062486646, 1.1124902e-05) (-0.00062525123, 1.1201436e-05) (-0.00062563177, 1.1296759e-05) (-0.00062600719, 1.1410639e-05) (-0.00062637656, 1.1542802e-05) (-0.000626739, 1.1692931e-05) (-0.00062709364, 1.1860663e-05) (-0.00062743962, 1.2045594e-05) (-0.00062777611, 1.2247279e-05) (-0.0006281023, 1.2465232e-05) (-0.00062841741, 1.2698928e-05) (-0.00062872066, 1.2947803e-05) (-0.00062901134, 1.3211259e-05) (-0.00062928874, 1.348866e-05) (-0.0006295522, 1.3779339e-05) (-0.00062980107, 1.4082595e-05) (-0.00063003477, 1.4397697e-05) (-0.00063025272, 1.4723887e-05) (-0.00063045441, 1.5060378e-05) (-0.00063063934, 1.540636e-05) (-0.00063080707, 1.5760999e-05) (-0.0006309572, 1.6123441e-05) (-0.00063108936, 1.6492814e-05) (-0.00063120324, 1.6868226e-05)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, closed, covered)
  pocket_cin = polyline(z=0, xy: (-0.0007525, -0.000135) (-0.0007525, 0.000135) (-0.00075244222, 0.00013617621) (-0.00075226942, 0.00013734108) (-0.00075198328, 0.00013848342) (-0.00075158655, 0.0001395922) (-0.00075108306, 0.00014065676) (-0.00075047764, 0.00014166684) (-0.00074977613, 0.00014261272) (-0.00074898528, 0.00014348528) (-0.00074811272, 0.00014427613) (-0.00074716684, 0.00014497764) (-0.00074615676, 0.00014558305) (-0.0007450922, 0.00014608655) (-0.00074398342, 0.00014648328) (-0.00074284108, 0.00014676942) (-0.00074167621, 0.00014694222) (-0.0007405, 0.000147) (-0.0005675, 0.000147) (-0.00056632379, 0.00014694222) (-0.00056515892, 0.00014676942) (-0.00056401658, 0.00014648328) (-0.0005629078, 0.00014608655) (-0.00056184324, 0.00014558305) (-0.00056083316, 0.00014497764) (-0.00055988728, 0.00014427613) (-0.00055901472, 0.00014348528) (-0.00055822388, 0.00014261272) (-0.00055752237, 0.00014166684) (-0.00055691694, 0.00014065676) (-0.00055641345, 0.0001395922) (-0.00055601672, 0.00013848342) (-0.00055573058, 0.00013734108) (-0.00055555778, 0.00013617621) (-0.0005555, 0.000135) (-0.0005555, -0.000135) (-0.00055555778, -0.00013617621) (-0.00055573058, -0.00013734108) (-0.00055601672, -0.00013848342) (-0.00055641345, -0.0001395922) (-0.00055691694, -0.00014065676) (-0.00055752237, -0.00014166684) (-0.00055822388, -0.00014261272) (-0.00055901472, -0.00014348528) (-0.00055988728, -0.00014427613) (-0.00056083316, -0.00014497764) (-0.00056184324, -0.00014558305) (-0.0005629078, -0.00014608655) (-0.00056401658, -0.00014648328) (-0.00056515892, -0.00014676942) (-0.00056632379, -0.00014694222) (-0.0005675, -0.000147) (-0.0007405, -0.000147) (-0.00074167621, -0.00014694222) (-0.00074284108, -0.00014676942) (-0.00074398342, -0.00014648328) (-0.0007450922, -0.00014608655) (-0.00074615676, -0.00014558305) (-0.00074716684, -0.00014497764) (-0.00074811272, -0.00014427613) (-0.00074898528, -0.00014348528) (-0.00074977613, -0.00014261272) (-0.00075047764, -0.00014166684) (-0.00075108306, -0.00014065676) (-0.00075158655, -0.0001395922) (-0.00075198328, -0.00013848342) (-0.00075226942, -0.00013734108) (-0.00075244222, -0.00013617621) (-0.0007525, -0.000135), closed, covered)
  tap_trace_n0 = polyline(z=0, xy: (0.00015, -5e-06) (-0.00015, -5e-06) (-0.00015, 5e-06) (-5e-06, 5e-06) (-5e-06, 0.0001) (5e-06, 0.0001) (5e-06, 5e-06) (0.00015, 5e-06) (0.00015, -5e-06), closed, covered)
  tap_cut_n0 = polyline(z=0, xy: (0.00015, -1.1e-05) (-0.00015, -1.1e-05) (-0.00015, 1.1e-05) (-1.1e-05, 1.1e-05) (-1.1e-05, 0.0001) (1.1e-05, 0.0001) (1.1e-05, 1.1e-05) (0.00015, 1.1e-05) (0.00015, -1.1e-05), closed, covered)
  plate_cp = polyline(z=0, xy: (7e-05, 0.00027) (6.9961478e-05, 0.00026921586) (6.9846282e-05, 0.00026843928) (6.9655523e-05, 0.00026767772) (6.9391036e-05, 0.00026693853) (6.905537e-05, 0.00026622883) (6.8651757e-05, 0.00026555544) (6.8184084e-05, 0.00026492485) (6.7656854e-05, 0.00026434315) (6.7075146e-05, 0.00026381592) (6.6444562e-05, 0.00026334824) (6.5771174e-05, 0.00026294463) (6.5061467e-05, 0.00026260896) (6.4322277e-05, 0.00026234448) (6.3560723e-05, 0.00026215372) (6.2784137e-05, 0.00026203852) (6.2e-05, 0.000262) (-6.2e-05, 0.000262) (-6.2784137e-05, 0.00026203852) (-6.3560723e-05, 0.00026215372) (-6.4322277e-05, 0.00026234448) (-6.5061467e-05, 0.00026260896) (-6.5771174e-05, 0.00026294463) (-6.6444562e-05, 0.00026334824) (-6.7075146e-05, 0.00026381592) (-6.7656854e-05, 0.00026434315) (-6.8184084e-05, 0.00026492485) (-6.8651757e-05, 0.00026555544) (-6.905537e-05, 0.00026622883) (-6.9391036e-05, 0.00026693853) (-6.9655523e-05, 0.00026767772) (-6.9846282e-05, 0.00026843928) (-6.9961478e-05, 0.00026921586) (-7e-05, 0.00027) (-7e-05, 0.000295) (-6.9961478e-05, 0.00029578414) (-6.9846282e-05, 0.00029656072) (-6.9655523e-05, 0.00029732228) (-6.9391036e-05, 0.00029806147) (-6.905537e-05, 0.00029877117) (-6.8651757e-05, 0.00029944456) (-6.8184084e-05, 0.00030007515) (-6.7656854e-05, 0.00030065685) (-6.7075146e-05, 0.00030118408) (-6.6444562e-05, 0.00030165176) (-6.5771174e-05, 0.00030205537) (-6.5061467e-05, 0.00030239104) (-6.4322277e-05, 0.00030265552) (-6.3560723e-05, 0.00030284628) (-6.2784137e-05, 0.00030296148) (-6.2e-05, 0.000303) (6.2e-05, 0.000303) (6.2784137e-05, 0.00030296148) (6.3560723e-05, 0.00030284628) (6.4322277e-05, 0.00030265552) (6.5061467e-05, 0.00030239104) (6.5771174e-05, 0.00030205537) (6.6444562e-05, 0.00030165176) (6.7075146e-05, 0.00030118408) (6.7656854e-05, 0.00030065685) (6.8184084e-05, 0.00030007515) (6.8651757e-05, 0.00029944456) (6.905537e-05, 0.00029877117) (6.9391036e-05, 0.00029806147) (6.9655523e-05, 0.00029732228) (6.9846282e-05, 0.00029656072) (6.9961478e-05, 0.00029578414) (7e-05, 0.000295) (7e-05, 0.00027), closed, covered)
  frame_cp = polyline(z=0, xy: (7e-05, 0.000254) (7.0784137e-05, 0.00025403852) (7.1560723e-05, 0.00025415372) (7.2322277e-05, 0.00025434448) (7.3061467e-05, 0.00025460896) (7.3771174e-05, 0.00025494463) (7.4444562e-05, 0.00025534824) (7.5075146e-05, 0.00025581592) (7.5656854e-05, 0.00025634315) (7.6184084e-05, 0.00025692485) (7.6651757e-05, 0.00025755544) (7.705537e-05, 0.00025822883) (7.7391036e-05, 0.00025893853) (7.7655523e-05, 0.00025967772) (7.7846282e-05, 0.00026043928) (7.7961478e-05, 0.00026121586) (7.8e-05, 0.000262) (7.8e-05, 0.000303) (7.7961478e-05, 0.00030378414) (7.7846282e-05, 0.00030456072) (7.7655523e-05, 0.00030532228) (7.7391036e-05, 0.00030606147) (7.705537e-05, 0.00030677117) (7.6651757e-05, 0.00030744456) (7.6184084e-05, 0.00030807515) (7.5656854e-05, 0.00030865685) (7.5075146e-05, 0.00030918408) (7.4444562e-05, 0.00030965176) (7.3771174e-05, 0.00031005537) (7.3061467e-05, 0.00031039104) (7.2322277e-05, 0.00031065552) (7.1560723e-05, 0.00031084628) (7.0784137e-05, 0.00031096148) (7e-05, 0.000311) (1.909818e-05, 0.000311) (1.8901939e-05, 0.00031100482) (1.8412015e-05, 0.00031102889) (1.80216e-05, 0.00031106734) (1.7633541e-05, 0.0003111249) (1.7248774e-05, 0.00031120144) (1.6868226e-05, 0.00031129676) (1.6492814e-05, 0.00031141064) (1.6123441e-05, 0.0003115428) (1.5760999e-05, 0.00031169293) (1.540636e-05, 0.00031186066) (1.5060378e-05, 0.00031204559) (1.4723887e-05, 0.00031224728) (1.4397697e-05, 0.00031246523) (1.4082595e-05, 0.00031269893) (1.3779339e-05, 0.0003129478) (1.348866e-05, 0.00031321126) (1.3211259e-05, 0.00031348866) (1.2947803e-05, 0.00031377934) (1.2698928e-05, 0.00031408259) (1.2465232e-05, 0.0003143977) (1.2247279e-05, 0.00031472389) (1.2045594e-05, 0.00031506038) (1.1860663e-05, 0.00031540636) (1.1692931e-05, 0.000315761) (1.1542802e-05, 0.00031612344) (1.1410639e-05, 0.00031649281) (1.1296759e-05, 0.00031686823) (1.1201436e-05, 0.00031724877) (1.1124902e-05, 0.00031763354) (1.1067338e-05, 0.0003180216) (1.1028886e-05, 0.00031841202) (1.1004817e-05, 0.00031890194) (1.1e-05, 0.00031909818) (1.1e-05, 0.00036690182) (1.1004817e-05, 0.00036709806) (1.1028886e-05, 0.00036758799) (1.1067338e-05, 0.0003679784) (1.1124902e-05, 0.00036836646) (1.1201436e-05, 0.00036875123) (1.1296759e-05, 0.00036913177) (1.1410639e-05, 0.00036950719) (1.1542802e-05, 0.00036987656) (1.1692931e-05, 0.000370239) (1.1860663e-05, 0.00037059364) (1.2045594e-05, 0.00037093962) (1.2247279e-05, 0.00037127611) (1.2465232e-05, 0.0003716023) (1.2698928e-05, 0.0003719174) (1.2947803e-05, 0.00037222066) (1.3211259e-05, 0.00037251134) (1.348866e-05, 0.00037278874) (1.3779339e-05, 0.0003730522) (1.4082595e-05, 0.00037330107) (1.4397697e-05, 0.00037353477) (1.4723887e-05, 0.00037375272) (1.5060378e-05, 0.00037395441) (1.540636e-05, 0.00037413934) (1.5760999e-05, 0.00037430707) (1.6123441e-05, 0.0003744572) (1.6492814e-05, 0.00037458936) (1.6868226e-05, 0.00037470324) (1.7248774e-05, 0.00037479856) (1.7633541e-05, 0.0003748751) (1.80216e-05, 0.00037493266) (1.8412015e-05, 0.00037497111) (1.8901939e-05, 0.00037499518) (1.909818e-05, 0.000375) (0.00012690182, 0.000375) (0.00012709806, 0.00037499518) (0.00012758798, 0.00037497111) (0.0001279784, 0.00037493266) (0.00012836646, 0.0003748751) (0.00012875123, 0.00037479856) (0.00012913177, 0.00037470324) (0.00012950719, 0.00037458936) (0.00012987656, 0.0003744572) (0.000130239, 0.00037430707) (0.00013059364, 0.00037413934) (0.00013093962, 0.00037395441) (0.00013127611, 0.00037375272) (0.0001316023, 0.00037353477) (0.00013191741, 0.00037330107) (0.00013222066, 0.0003730522) (0.00013251134, 0.00037278874) (0.00013278874, 0.00037251134) (0.0001330522, 0.00037222066) (0.00013330107, 0.0003719174) (0.00013353477, 0.0003716023) (0.00013375272, 0.00037127611) (0.00013395441, 0.00037093962) (0.00013413934, 0.00037059364) (0.00013430707, 0.000370239) (0.0001344572, 0.00036987656) (0.00013458936, 0.00036950719) (0.00013470324, 0.00036913177) (0.00013479856, 0.00036875123) (0.0001348751, 0.00036836646) (0.00013493266, 0.0003679784) (0.00013497111, 0.00036758799) (0.00013499518, 0.00036709806) (0.000135, 0.00036690182) (0.000135, 0.00021009818) (0.00013499518, 0.00020990194) (0.00013497111, 0.00020941201) (0.00013493266, 0.0002090216) (0.0001348751, 0.00020863354) (0.00013479856, 0.00020824877) (0.00013470324, 0.00020786823) (0.00013458936, 0.00020749281) (0.0001344572, 0.00020712344) (0.00013430707, 0.000206761) (0.00013413934, 0.00020640636) (0.00013395441, 0.00020606038) (0.00013375272, 0.00020572389) (0.00013353477, 0.0002053977) (0.00013330107, 0.00020508259) (0.0001330522, 0.00020477934) (0.00013278874, 0.00020448866) (0.00013251134, 0.00020421126) (0.00013222066, 0.0002039478) (0.00013191741, 0.00020369893) (0.0001316023, 0.00020346523) (0.00013127611, 0.00020324728) (0.00013093962, 0.00020304559) (0.00013059364, 0.00020286066) (0.000130239, 0.00020269293) (0.00012987656, 0.0002025428) (0.00012950719, 0.00020241064) (0.00012913177, 0.00020229676) (0.00012875123, 0.00020220144) (0.00012836646, 0.0002021249) (0.0001279784, 0.00020206734) (0.00012758798, 0.00020202889) (0.00012709806, 0.00020200482) (0.00012690182, 0.000202) (-0.00012690182, 0.000202) (-0.00012709806, 0.00020200482) (-0.00012758798, 0.00020202889) (-0.0001279784, 0.00020206734) (-0.00012836646, 0.0002021249) (-0.00012875123, 0.00020220144) (-0.00012913177, 0.00020229676) (-0.00012950719, 0.00020241064) (-0.00012987656, 0.0002025428) (-0.000130239, 0.00020269293) (-0.00013059364, 0.00020286066) (-0.00013093962, 0.00020304559) (-0.00013127611, 0.00020324728) (-0.0001316023, 0.00020346523) (-0.00013191741, 0.00020369893) (-0.00013222066, 0.0002039478) (-0.00013251134, 0.00020421126) (-0.00013278874, 0.00020448866) (-0.0001330522, 0.00020477934) (-0.00013330107, 0.00020508259) (-0.00013353477, 0.0002053977) (-0.00013375272, 0.00020572389) (-0.00013395441, 0.00020606038) (-0.00013413934, 0.00020640636) (-0.00013430707, 0.000206761) (-0.0001344572, 0.00020712344) (-0.00013458936, 0.00020749281) (-0.00013470324, 0.00020786823) (-0.00013479856, 0.00020824877) (-0.0001348751, 0.00020863354) (-0.00013493266, 0.0002090216) (-0.00013497111, 0.00020941201) (-0.00013499518, 0.00020990194) (-0.000135, 0.00021009818) (-0.000135, 0.00036690182) (-0.00013499518, 0.00036709806) (-0.00013497111, 0.00036758799) (-0.00013493266, 0.0003679784) (-0.0001348751, 0.00036836646) (-0.00013479856, 0.00036875123) (-0.00013470324, 0.00036913177) (-0.00013458936, 0.00036950719) (-0.0001344572, 0.00036987656) (-0.00013430707, 0.000370239) (-0.00013413934, 0.00037059364) (-0.00013395441, 0.00037093962) (-0.00013375272, 0.00037127611) (-0.00013353477, 0.0003716023) (-0.00013330107, 0.0003719174) (-0.0001330522, 0.00037222066) (-0.00013278874, 0.00037251134) (-0.00013251134, 0.00037278874) (-0.00013222066, 0.0003730522) (-0.00013191741, 0.00037330107) (-0.0001316023, 0.00037353477) (-0.00013127611, 0.00037375272) (-0.00013093962, 0.00037395441) (-0.00013059364, 0.00037413934) (-0.000130239, 0.00037430707) (-0.00012987656, 0.0003744572) (-0.00012950719, 0.00037458936) (-0.00012913177, 0.00037470324) (-0.00012875123, 0.00037479856) (-0.00012836646, 0.0003748751) (-0.0001279784, 0.00037493266) (-0.00012758798, 0.00037497111) (-0.00012709806, 0.00037499518) (-0.00012690182, 0.000375) (-1.909818e-05, 0.000375) (-1.8901939e-05, 0.00037499518) (-1.8412015e-05, 0.00037497111) (-1.80216e-05, 0.00037493266) (-1.7633541e-05, 0.0003748751) (-1.7248774e-05, 0.00037479856) (-1.6868226e-05, 0.00037470324) (-1.6492814e-05, 0.00037458936) (-1.6123441e-05, 0.0003744572) (-1.5760999e-05, 0.00037430707) (-1.540636e-05, 0.00037413934) (-1.5060378e-05, 0.00037395441) (-1.4723887e-05, 0.00037375272) (-1.4397697e-05, 0.00037353477) (-1.4082595e-05, 0.00037330107) (-1.3779339e-05, 0.0003730522) (-1.348866e-05, 0.00037278874) (-1.3211259e-05, 0.00037251134) (-1.2947803e-05, 0.00037222066) (-1.2698928e-05, 0.0003719174) (-1.2465232e-05, 0.0003716023) (-1.2247279e-05, 0.00037127611) (-1.2045594e-05, 0.00037093962) (-1.1860663e-05, 0.00037059364) (-1.1692931e-05, 0.000370239) (-1.1542802e-05, 0.00036987656) (-1.1410639e-05, 0.00036950719) (-1.1296759e-05, 0.00036913177) (-1.1201436e-05, 0.00036875123) (-1.1124902e-05, 0.00036836646) (-1.1067338e-05, 0.0003679784) (-1.1028886e-05, 0.00036758799) (-1.1004817e-05, 0.00036709806) (-1.1e-05, 0.00036690182) (-1.1e-05, 0.00031909818) (-1.1004817e-05, 0.00031890194) (-1.1028886e-05, 0.00031841202) (-1.1067338e-05, 0.0003180216) (-1.1124902e-05, 0.00031763354) (-1.1201436e-05, 0.00031724877) (-1.1296759e-05, 0.00031686823) (-1.1410639e-05, 0.00031649281) (-1.1542802e-05, 0.00031612344) (-1.1692931e-05, 0.000315761) (-1.1860663e-05, 0.00031540636) (-1.2045594e-05, 0.00031506038) (-1.2247279e-05, 0.00031472389) (-1.2465232e-05, 0.0003143977) (-1.2698928e-05, 0.00031408259) (-1.2947803e-05, 0.00031377934) (-1.3211259e-05, 0.00031348866) (-1.348866e-05, 0.00031321126) (-1.3779339e-05, 0.0003129478) (-1.4082595e-05, 0.00031269893) (-1.4397697e-05, 0.00031246523) (-1.4723887e-05, 0.00031224728) (-1.5060378e-05, 0.00031204559) (-1.540636e-05, 0.00031186066) (-1.5760999e-05, 0.00031169293) (-1.6123441e-05, 0.0003115428) (-1.6492814e-05, 0.00031141064) (-1.6868226e-05, 0.00031129676)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, closed, covered)
  pocket_cp = polyline(z=0, xy: (0.000135, 0.00019) (-0.000135, 0.00019) (-0.00013617621, 0.00019005778) (-0.00013734108, 0.00019023058) (-0.00013848342, 0.00019051672) (-0.0001395922, 0.00019091345) (-0.00014065676, 0.00019141694) (-0.00014166684, 0.00019202237) (-0.00014261272, 0.00019272388) (-0.00014348528, 0.00019351472) (-0.00014427613, 0.00019438728) (-0.00014497764, 0.00019533316) (-0.00014558305, 0.00019634324) (-0.00014608655, 0.0001974078) (-0.00014648328, 0.00019851658) (-0.00014676942, 0.00019965892) (-0.00014694222, 0.00020082379) (-0.000147, 0.000202) (-0.000147, 0.000375) (-0.00014694222, 0.00037617621) (-0.00014676942, 0.00037734108) (-0.00014648328, 0.00037848342) (-0.00014608655, 0.0003795922) (-0.00014558305, 0.00038065676) (-0.00014497764, 0.00038166684) (-0.00014427613, 0.00038261272) (-0.00014348528, 0.00038348528) (-0.00014261272, 0.00038427613) (-0.00014166684, 0.00038497764) (-0.00014065676, 0.00038558305) (-0.0001395922, 0.00038608655) (-0.00013848342, 0.00038648328) (-0.00013734108, 0.00038676942) (-0.00013617621, 0.00038694222) (-0.000135, 0.000387) (0.000135, 0.000387) (0.00013617621, 0.00038694222) (0.00013734108, 0.00038676942) (0.00013848342, 0.00038648328) (0.0001395922, 0.00038608655) (0.00014065676, 0.00038558305) (0.00014166684, 0.00038497764) (0.00014261272, 0.00038427613) (0.00014348528, 0.00038348528) (0.00014427613, 0.00038261272) (0.00014497764, 0.00038166684) (0.00014558305, 0.00038065676) (0.00014608655, 0.0003795922) (0.00014648328, 0.00037848342) (0.00014676942, 0.00037734108) (0.00014694222, 0.00037617621) (0.000147, 0.000375) (0.000147, 0.000202) (0.00014694222, 0.00020082379) (0.00014676942, 0.00019965892) (0.00014648328, 0.00019851658) (0.00014608655, 0.0001974078) (0.00014558305, 0.00019634324) (0.00014497764, 0.00019533316) (0.00014427613, 0.00019438728) (0.00014348528, 0.00019351472) (0.00014261272, 0.00019272388) (0.00014166684, 0.00019202237) (0.00014065676, 0.00019141694) (0.0001395922, 0.00019091345) (0.00013848342, 0.00019051672) (0.00013734108, 0.00019023058) (0.00013617621, 0.00019005778) (0.000135, 0.00019), closed, covered)
  tap_trace_jf = polyline(z=0, xy: (-5e-06, 0.001465) (-5e-06, 0.001765) (5e-06, 0.001765) (5e-06, 0.00162) (7.55e-05, 0.00162) (7.55e-05, 0.00161) (5e-06, 0.00161) (5e-06, 0.001465) (-5e-06, 0.001465), closed, covered)
  tap_cut_jf = polyline(z=0, xy: (-1.1e-05, 0.001465) (-1.1e-05, 0.001765) (1.1e-05, 0.001765) (1.1e-05, 0.001626) (7.55e-05, 0.001626) (7.55e-05, 0.001604) (1.1e-05, 0.001604) (1.1e-05, 0.001465) (-1.1e-05, 0.001465), closed, covered)
  tap_trace_jr = polyline(z=0, xy: (0.0001745, 0.00162) (0.000245, 0.00162) (0.000245, 0.001765) (0.000255, 0.001765) (0.000255, 0.001465) (0.000245, 0.001465) (0.000245, 0.00161) (0.0001745, 0.00161) (0.0001745, 0.00162), closed, covered)
  tap_cut_jr = polyline(z=0, xy: (0.0001745, 0.001626) (0.000239, 0.001626) (0.000239, 0.001765) (0.000261, 0.001765) (0.000261, 0.001465) (0.000239, 0.001465) (0.000239, 0.001604) (0.0001745, 0.001604) (0.0001745, 0.001626), closed, covered)
  head_a_cj = polyline(z=0, xy: (0.0001075, 0.001596) (0.00010730397, 0.0015960096) (0.00010710982, 0.0015960384) (0.00010691943, 0.0015960861) (0.00010673463, 0.0015961522) (0.00010655721, 0.0015962362) (0.00010638886, 0.0015963371) (0.00010623121, 0.001596454) (0.00010608579, 0.0015965858) (0.00010595398, 0.0015967312) (0.00010583706, 0.0015968889) (0.00010573616, 0.0015970572) (0.00010565224, 0.0015972346) (0.00010558612, 0.0015974194) (0.00010553843, 0.0015976098) (0.00010550963, 0.001597804) (0.0001055, 0.001598) (0.0001055, 0.001632) (0.00010550963, 0.001632196) (0.00010553843, 0.0016323902) (0.00010558612, 0.0016325806) (0.00010565224, 0.0016327654) (0.00010573616, 0.0016329428) (0.00010583706, 0.0016331111) (0.00010595398, 0.0016332688) (0.00010608579, 0.0016334142) (0.00010623121, 0.001633546) (0.00010638886, 0.0016336629) (0.00010655721, 0.0016337638) (0.00010673463, 0.0016338478) (0.00010691943, 0.0016339139) (0.00010710982, 0.0016339616) (0.00010730397, 0.0016339904) (0.0001075, 0.001634) (0.0001185, 0.001634) (0.00011869603, 0.0016339904) (0.00011889018, 0.0016339616) (0.00011908057, 0.0016339139) (0.00011926537, 0.0016338478) (0.00011944279, 0.0016337638) (0.00011961114, 0.0016336629) (0.00011976879, 0.001633546) (0.00011991421, 0.0016334142) (0.00012004602, 0.0016332688) (0.00012016294, 0.0016331111) (0.00012026384, 0.0016329428) (0.00012034776, 0.0016327654) (0.00012041388, 0.0016325806) (0.00012046157, 0.0016323902) (0.00012049037, 0.001632196) (0.0001205, 0.001632) (0.0001205, 0.001598) (0.00012049037, 0.001597804) (0.00012046157, 0.0015976098) (0.00012041388, 0.0015974194) (0.00012034776, 0.0015972346) (0.00012026384, 0.0015970572) (0.00012016294, 0.0015968889) (0.00012004602, 0.0015967312) (0.00011991421, 0.0015965858) (0.00011976879, 0.001596454) (0.00011961114, 0.0015963371) (0.00011944279, 0.0015962362) (0.00011926537, 0.0015961522) (0.00011908057, 0.0015960861) (0.00011889018, 0.0015960384) (0.00011869603, 0.0015960096) (0.0001185, 0.001596) (0.0001075, 0.001596), closed, covered)
  head_b_cj = polyline(z=0, xy: (0.0001315, 0.001596) (0.00013130397, 0.0015960096) (0.00013110982, 0.0015960384) (0.00013091943, 0.0015960861) (0.00013073463, 0.0015961522) (0.00013055721, 0.0015962362) (0.00013038886, 0.0015963371) (0.00013023121, 0.001596454) (0.00013008579, 0.0015965858) (0.00012995398, 0.0015967312) (0.00012983706, 0.0015968889) (0.00012973616, 0.0015970572) (0.00012965224, 0.0015972346) (0.00012958612, 0.0015974194) (0.00012953843, 0.0015976098) (0.00012950963, 0.001597804) (0.0001295, 0.001598) (0.0001295, 0.001632) (0.00012950963, 0.001632196) (0.00012953843, 0.0016323902) (0.00012958612, 0.0016325806) (0.00012965224, 0.0016327654) (0.00012973616, 0.0016329428) (0.00012983706, 0.0016331111) (0.00012995398, 0.0016332688) (0.00013008579, 0.0016334142) (0.00013023121, 0.001633546) (0.00013038886, 0.0016336629) (0.00013055721, 0.0016337638) (0.00013073463, 0.0016338478) (0.00013091943, 0.0016339139) (0.00013110982, 0.0016339616) (0.00013130397, 0.0016339904) (0.0001315, 0.001634) (0.0001425, 0.001634) (0.00014269603, 0.0016339904) (0.00014289018, 0.0016339616) (0.00014308057, 0.0016339139) (0.00014326537, 0.0016338478) (0.00014344279, 0.0016337638) (0.00014361114, 0.0016336629) (0.00014376879, 0.001633546) (0.00014391421, 0.0016334142) (0.00014404602, 0.0016332688) (0.00014416294, 0.0016331111) (0.00014426384, 0.0016329428) (0.00014434776, 0.0016327654) (0.00014441388, 0.0016325806) (0.00014446157, 0.0016323902) (0.00014449037, 0.001632196) (0.0001445, 0.001632) (0.0001445, 0.001598) (0.00014449037, 0.001597804) (0.00014446157, 0.0015976098) (0.00014441388, 0.0015974194) (0.00014434776, 0.0015972346) (0.00014426384, 0.0015970572) (0.00014416294, 0.0015968889) (0.00014404602, 0.0015967312) (0.00014391421, 0.0015965858) (0.00014376879, 0.001596454) (0.00014361114, 0.0015963371) (0.00014344279, 0.0015962362) (0.00014326537, 0.0015961522) (0.00014308057, 0.0015960861) (0.00014289018, 0.0015960384) (0.00014269603, 0.0015960096) (0.0001425, 0.001596) (0.0001315, 0.001596), closed, covered)
  pocket_cj = polyline(z=0, xy: (9.75e-05, 0.001586) (9.7303966e-05, 0.0015860096) (9.7109819e-05, 0.0015860384) (9.6919431e-05, 0.0015860861) (9.6734633e-05, 0.0015861522) (9.6557207e-05, 0.0015862362) (9.638886e-05, 0.0015863371) (9.6231213e-05, 0.001586454) (9.6085786e-05, 0.0015865858) (9.5953979e-05, 0.0015867312) (9.5837061e-05, 0.0015868889) (9.5736157e-05, 0.0015870572) (9.5652241e-05, 0.0015872346) (9.5586119e-05, 0.0015874194) (9.5538429e-05, 0.0015876098) (9.5509631e-05, 0.001587804) (9.55e-05, 0.001588) (9.55e-05, 0.001642) (9.5509631e-05, 0.001642196) (9.5538429e-05, 0.0016423902) (9.5586119e-05, 0.0016425806) (9.5652241e-05, 0.0016427654) (9.5736157e-05, 0.0016429428) (9.5837061e-05, 0.0016431111) (9.5953979e-05, 0.0016432688) (9.6085786e-05, 0.0016434142) (9.6231213e-05, 0.001643546) (9.638886e-05, 0.0016436629) (9.6557207e-05, 0.0016437638) (9.6734633e-05, 0.0016438478) (9.6919431e-05, 0.0016439139) (9.7109819e-05, 0.0016439616) (9.7303966e-05, 0.0016439904) (9.75e-05, 0.001644) (0.0001525, 0.001644) (0.00015269603, 0.0016439904) (0.00015289018, 0.0016439616) (0.00015308057, 0.0016439139) (0.00015326537, 0.0016438478) (0.00015344279, 0.0016437638) (0.00015361114, 0.0016436629) (0.00015376879, 0.001643546) (0.00015391421, 0.0016434142) (0.00015404602, 0.0016432688) (0.00015416294, 0.0016431111) (0.00015426384, 0.0016429428) (0.00015434776, 0.0016427654) (0.00015441388, 0.0016425806) (0.00015446157, 0.0016423902) (0.00015449037, 0.001642196) (0.0001545, 0.001642) (0.0001545, 0.001588) (0.00015449037, 0.001587804) (0.00015446157, 0.0015876098) (0.00015441388, 0.0015874194) (0.00015434776, 0.0015872346) (0.00015426384, 0.0015870572) (0.00015416294, 0.0015868889) (0.00015404602, 0.0015867312) (0.00015391421, 0.0015865858) (0.00015376879, 0.001586454) (0.00015361114, 0.0015863371) (0.00015344279, 0.0015862362) (0.00015326537, 0.0015861522) (0.00015308057, 0.0015860861) (0.00015289018, 0.0015860384) (0.00015269603, 0.0015860096) (0.0001525, 0.001586) (9.75e-05, 0.001586), closed, covered)
  open_to_ground_readout_open = rectangle(corner=(0.000239, 0.002915, 0), x_size=2.2e-05, y_size=6e-06)
  endcap_feed_in_start = rectangle(corner=(-0.001626, -1.1e-05, 0), x_size=6e-06, y_size=2.2e-05)
  endcap_feed_out_end = rectangle(corner=(0.00162, -1.1e-05, 0), x_size=6e-06, y_size=2.2e-05)
  ground_main_plane = rectangle(corner=(-0.00182, -0.000347, 0), x_size=0.00364, y_size=0.003468)
  main [silicon_eps11p45] = box(corner=(-0.00182, -0.000347, -0.0005), size=(0.00364, 0.003468, 0.0005))
  sample_holder [vacuum] = box(corner=(-0.00182, -0.000347, -0.00165), size=(0.00364, 0.003468, 0.00254))
  ground_main_plane.subtract(pocket_cp, tap_cut_jr, pocket_cj, tap_cut_n0, cut_stub_p, open_to_ground_readout_open, cut_stub_r, endcap_feed_in_start, lead_a_sub_cp, lead_b_sub_cj, cut_filter_tail, endcap_feed_out_end, cut_stub_f, pocket_cin, cut_feed_in, lead_b_sub_cin, lead_b_sub_cp, cut_feed_mid, lead_a_sub_cj, lead_a_sub_cin, cut_res_tail, tap_cut_jf, cut_feed_out, cut_res_open_run, cut_feed_jf)
  Port_feed_in_start = rectangle(corner=(-0.001626, -5e-06, 0), x_size=6e-06, y_size=1e-05)
  voltage_line_Port_feed_in_start = polyline((-0.00162, 0, 0) (-0.001626, 0, 0))
  Port_feed_out_end = rectangle(corner=(0.00162, -5e-06, 0), x_size=6e-06, y_size=1e-05)
  voltage_line_Port_feed_out_end = polyline((0.00162, 0, 0) (0.001626, 0, 0))
  g_wb_13 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=5.325e-05 YPadPos=0.001585 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_14 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00019675 YPadPos=0.001585 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
boundaries and excitations:
  RLCBoundary_feed_in_start: Lumped RLC Objects=Port_feed_in_start CurrentLine{middle of Port_feed_in_start.edge(x at corner) -> middle of Port_feed_in_start.edge(x opposite corner)} RLC_Type=Parallel Resistance=50ohm
  RLCBoundary_feed_out_end: Lumped RLC Objects=Port_feed_out_end CurrentLine{middle of Port_feed_out_end.edge(x at corner) -> middle of Port_feed_out_end.edge(x opposite corner)} RLC_Type=Parallel Resistance=50ohm
  PerfE: Perfect E Objects=[lead_a_cin, lead_b_cin, lead_a_cp, lead_b_cp, trace_feed_in, trace_feed_mid, trace_feed_out, trace_stub_p, lead_a_cj, lead_b_cj, trace_stub_f, trace_stub_r, trace_feed_jf, trace_res_open_run, trace_filter_tail, trace_res_tail, plate_cin, frame_cin, tap_trace_n0, plate_cp, frame_cp, tap_trace_jf, tap_trace_jr, head_a_cj, head_b_cj, ground_main_plane]
mesh:
  port_mesh: LengthBased Objects=[Port_feed_in_start, Port_feed_out_end] MaxLength=7um
  cpw_line_mesh: LengthBased Objects=[lead_a_cin, lead_b_cin, trace_feed_in, trace_feed_mid, trace_feed_out, trace_stub_p, trace_stub_f, trace_stub_r, trace_feed_jf, trace_res_open_run, trace_filter_tail, trace_res_tail, plate_cin, frame_cin, tap_trace_n0, tap_trace_jf, tap_trace_jr] MaxLength=20um
  cap_mesh: LengthBased Objects=[lead_a_cp, lead_b_cp, lead_a_cj, lead_b_cj, plate_cp, frame_cp, head_a_cj, head_b_cj] MaxLength=9um
setups:
  Setup: HfssEigen MinimumFrequency=5.95GHz NumModes=2 MaxDeltaFreq=0.1 ConvergeOnRealFreq=true MaximumPasses=15 MinimumPasses=3 MinimumConvergedPasses=2 PercentRefinement=20 BasisOrder=1
source amplitudes:
  #-10:1: 1 0deg
  #-10:2: 0 0deg
reports:
  Freq. vs. pass: re(Mode(1)), re(Mode(2)) vs Pass on Setup : AdaptivePass

design P250g9_straps_p30um_1852_hfss (HFSS, Eigenmode, model units mm)
geometry:
  lead_a_cin_path = polyline((-0.000740499, 0, 0) (-0.0007925, 0, 0))
  lead_a_cin = polyline((-0.000740499, -5e-06, 0) (-0.000740499, 5e-06, 0))
  lead_a_cin.sweep_along_path(lead_a_cin_path)
  lead_a_sub_cin_path = polyline((-0.000740499, 0, 0) (-0.0007925, 0, 0))
  lead_a_sub_cin = polyline((-0.000740499, -1.1e-05, 0) (-0.000740499, 1.1e-05, 0))
  lead_a_sub_cin.sweep_along_path(lead_a_sub_cin_path)
  lead_b_cin_path = polyline((-0.000639501, 0, 0) (-0.0005275, 0, 0))
  lead_b_cin = polyline((-0.000639501, 5e-06, 0) (-0.000639501, -5e-06, 0))
  lead_b_cin.sweep_along_path(lead_b_cin_path)
  lead_b_sub_cin_path = polyline((-0.000639501, 0, 0) (-0.0005275, 0, 0))
  lead_b_sub_cin = polyline((-0.000639501, 1.1e-05, 0) (-0.000639501, -1.1e-05, 0))
  lead_b_sub_cin.sweep_along_path(lead_b_sub_cin_path)
  lead_a_cp_path = polyline((0, 0.000202001, 0) (0, 0.00015, 0))
  lead_a_cp = polyline((5e-06, 0.000202001, 0) (-5e-06, 0.000202001, 0))
  lead_a_cp.sweep_along_path(lead_a_cp_path)
  lead_a_sub_cp_path = polyline((0, 0.000202001, 0) (0, 0.00015, 0))
  lead_a_sub_cp = polyline((1.1e-05, 0.000202001, 0) (-1.1e-05, 0.000202001, 0))
  lead_a_sub_cp.sweep_along_path(lead_a_sub_cp_path)
  lead_b_cp_path = polyline((0, 0.000302999, 0) (0, 0.000415, 0))
  lead_b_cp = polyline((-5e-06, 0.000302999, 0) (5e-06, 0.000302999, 0))
  lead_b_cp.sweep_along_path(lead_b_cp_path)
  lead_b_sub_cp_path = polyline((0, 0.000302999, 0) (0, 0.000415, 0))
  lead_b_sub_cp = polyline((-1.1e-05, 0.000302999, 0) (1.1e-05, 0.000302999, 0))
  lead_b_sub_cp.sweep_along_path(lead_b_sub_cp_path)
  trace_feed_in_path = polyline((-0.00162, 0, 0) (-0.0007925, 0, 0))
  trace_feed_in = polyline((-0.00162, 5e-06, 0) (-0.00162, -5e-06, 0))
  trace_feed_in.sweep_along_path(trace_feed_in_path)
  cut_feed_in_path = polyline((-0.00162, 0, 0) (-0.0007925, 0, 0))
  cut_feed_in = polyline((-0.00162, 1.1e-05, 0) (-0.00162, -1.1e-05, 0))
  cut_feed_in.sweep_along_path(cut_feed_in_path)
  trace_feed_mid_path = polyline((-0.0005275, 0, 0) (-0.00015, 0, 0))
  trace_feed_mid = polyline((-0.0005275, 5e-06, 0) (-0.0005275, -5e-06, 0))
  trace_feed_mid.sweep_along_path(trace_feed_mid_path)
  cut_feed_mid_path = polyline((-0.0005275, 0, 0) (-0.00015, 0, 0))
  cut_feed_mid = polyline((-0.0005275, 1.1e-05, 0) (-0.0005275, -1.1e-05, 0))
  cut_feed_mid.sweep_along_path(cut_feed_mid_path)
  trace_feed_out_path = polyline((0.00015, 0, 0) (0.00162, 0, 0))
  trace_feed_out = polyline((0.00015, 5e-06, 0) (0.00015, -5e-06, 0))
  trace_feed_out.sweep_along_path(trace_feed_out_path)
  cut_feed_out_path = polyline((0.00015, 0, 0) (0.00162, 0, 0))
  cut_feed_out = polyline((0.00015, 1.1e-05, 0) (0.00015, -1.1e-05, 0))
  cut_feed_out.sweep_along_path(cut_feed_out_path)
  trace_stub_p_path = polyline((0, 0.0001, 0) (0, 0.00015, 0))
  trace_stub_p = polyline((-5e-06, 0.0001, 0) (5e-06, 0.0001, 0))
  trace_stub_p.sweep_along_path(trace_stub_p_path)
  cut_stub_p_path = polyline((0, 0.0001, 0) (0, 0.00015, 0))
  cut_stub_p = polyline((-1.1e-05, 0.0001, 0) (1.1e-05, 0.0001, 0))
  cut_stub_p.sweep_along_path(cut_stub_p_path)
  lead_a_cj_path = polyline((0.000105501, 0.001615, 0) (9.55e-05, 0.001615, 0))
  lead_a_cj = polyline((0.000105501, 0.00161, 0) (0.000105501, 0.00162, 0))
  lead_a_cj.sweep_along_path(lead_a_cj_path)
  lead_a_sub_cj_path = polyline((0.000105501, 0.001615, 0) (9.55e-05, 0.001615, 0))
  lead_a_sub_cj = polyline((0.000105501, 0.001604, 0) (0.000105501, 0.001626, 0))
  lead_a_sub_cj.sweep_along_path(lead_a_sub_cj_path)
  lead_b_cj_path = polyline((0.000144499, 0.001615, 0) (0.0001545, 0.001615, 0))
  lead_b_cj = polyline((0.000144499, 0.00162, 0) (0.000144499, 0.00161, 0))
  lead_b_cj.sweep_along_path(lead_b_cj_path)
  lead_b_sub_cj_path = polyline((0.000144499, 0.001615, 0) (0.0001545, 0.001615, 0))
  lead_b_sub_cj = polyline((0.000144499, 0.001626, 0) (0.000144499, 0.001604, 0))
  lead_b_sub_cj.sweep_along_path(lead_b_sub_cj_path)
  trace_stub_f_path = polyline((7.55e-05, 0.001615, 0) (9.55e-05, 0.001615, 0))
  trace_stub_f = polyline((7.55e-05, 0.00162, 0) (7.55e-05, 0.00161, 0))
  trace_stub_f.sweep_along_path(trace_stub_f_path)
  cut_stub_f_path = polyline((7.55e-05, 0.001615, 0) (9.55e-05, 0.001615, 0))
  cut_stub_f = polyline((7.55e-05, 0.001626, 0) (7.55e-05, 0.001604, 0))
  cut_stub_f.sweep_along_path(cut_stub_f_path)
  trace_stub_r_path = polyline((0.0001545, 0.001615, 0) (0.0001745, 0.001615, 0))
  trace_stub_r = polyline((0.0001545, 0.00162, 0) (0.0001545, 0.00161, 0))
  trace_stub_r.sweep_along_path(trace_stub_r_path)
  cut_stub_r_path = polyline((0.0001545, 0.001615, 0) (0.0001745, 0.001615, 0))
  cut_stub_r = polyline((0.0001545, 0.001626, 0) (0.0001545, 0.001604, 0))
  cut_stub_r.sweep_along_path(cut_stub_r_path)
  trace_feed_jf_path = polyline((0, 0.000415, 0) (0, 0.001465, 0))
  trace_feed_jf = polyline((-5e-06, 0.000415, 0) (5e-06, 0.000415, 0))
  trace_feed_jf.sweep_along_path(trace_feed_jf_path)
  cut_feed_jf_path = polyline((0, 0.000415, 0) (0, 0.001465, 0))
  cut_feed_jf = polyline((-1.1e-05, 0.000415, 0) (1.1e-05, 0.000415, 0))
  cut_feed_jf.sweep_along_path(cut_feed_jf_path)
  trace_res_open_run_path = polyline((0.00025, 0.001765, 0) (0.00025, 0.002915, 0))
  trace_res_open_run = polyline((0.000245, 0.001765, 0) (0.000255, 0.001765, 0))
  trace_res_open_run.sweep_along_path(trace_res_open_run_path)
  cut_res_open_run_path = polyline((0.00025, 0.001765, 0) (0.00025, 0.002915, 0))
  cut_res_open_run = polyline((0.000239, 0.001765, 0) (0.000261, 0.001765, 0))
  cut_res_open_run.sweep_along_path(cut_res_open_run_path)
  trace_filter_tail_path = polyline(z=0, xy: (0, 0.001765) (0, 0.002285) (-0.00051923387, 0.002285) (-0.00051923387, 0.002055) (-0.00025, 0.002055) (-0.00025, 0.001825) (-0.00051923387, 0.001825) (-0.00051923387, 0.001595) (-0.00025, 0.001595) (-0.00025, 0.001365) (-0.00051923387, 0.001365) (-0.00051923387, 0.001135))
  trace_filter_tail_path.fillet(Vertices=trace_filter_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  trace_filter_tail = polyline((-5e-06, 0.001765, 0) (5e-06, 0.001765, 0))
  trace_filter_tail.sweep_along_path(trace_filter_tail_path)
  cut_filter_tail_path = polyline(z=0, xy: (0, 0.001765) (0, 0.002285) (-0.00051923387, 0.002285) (-0.00051923387, 0.002055) (-0.00025, 0.002055) (-0.00025, 0.001825) (-0.00051923387, 0.001825) (-0.00051923387, 0.001595) (-0.00025, 0.001595) (-0.00025, 0.001365) (-0.00051923387, 0.001365) (-0.00051923387, 0.001135))
  cut_filter_tail_path.fillet(Vertices=cut_filter_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  cut_filter_tail = polyline((-1.1e-05, 0.001765, 0) (1.1e-05, 0.001765, 0))
  cut_filter_tail.sweep_along_path(cut_filter_tail_path)
  trace_res_tail_path = polyline(z=0, xy: (0.00025, 0.001465) (0.00025, 0.000765) (0.00077617693, 0.000765) (0.00077617693, 0.000995) (0.0005, 0.000995) (0.0005, 0.001225) (0.00077617693, 0.001225) (0.00077617693, 0.001455) (0.0005, 0.001455) (0.0005, 0.001685) (0.00077617693, 0.001685) (0.00077617693, 0.001945))
  trace_res_tail_path.fillet(Vertices=trace_res_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  trace_res_tail = polyline((0.000255, 0.001465, 0) (0.000245, 0.001465, 0))
  trace_res_tail.sweep_along_path(trace_res_tail_path)
  cut_res_tail_path = polyline(z=0, xy: (0.00025, 0.001465) (0.00025, 0.000765) (0.00077617693, 0.000765) (0.00077617693, 0.000995) (0.0005, 0.000995) (0.0005, 0.001225) (0.00077617693, 0.001225) (0.00077617693, 0.001455) (0.0005, 0.001455) (0.0005, 0.001685) (0.00077617693, 0.001685) (0.00077617693, 0.001945))
  cut_res_tail_path.fillet(Vertices=cut_res_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  cut_res_tail = polyline((0.000261, 0.001465, 0) (0.000239, 0.001465, 0))
  cut_res_tail.sweep_along_path(cut_res_tail_path)
  g_wb [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.0013441667 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_1 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.0010683333 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_2 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.0005175 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_3 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000885 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_4 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.0012525 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_5 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=5.5e-05 YPadPos=0.000765 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_6 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=5.5e-05 YPadPos=0.001115 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_7 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000305 YPadPos=0.0021483333 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_8 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000305 YPadPos=0.0025316667 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_9 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=5.5e-05 YPadPos=0.002025 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_10 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00025961694 YPadPos=0.00234 ZPadPos=0 XDir=0 YDir=-1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_11 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000195 YPadPos=0.001115 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_12 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00051308846 YPadPos=0.00071 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  plate_cin = polyline(z=0, xy: (-0.0006725, -7e-05) (-0.00067328414, -6.9961478e-05) (-0.00067406072, -6.9846282e-05) (-0.00067482228, -6.9655523e-05) (-0.00067556147, -6.9391036e-05) (-0.00067627117, -6.905537e-05) (-0.00067694456, -6.8651757e-05) (-0.00067757515, -6.8184084e-05) (-0.00067815685, -6.7656854e-05) (-0.00067868408, -6.7075146e-05) (-0.00067915176, -6.6444562e-05) (-0.00067955537, -6.5771174e-05) (-0.00067989104, -6.5061467e-05) (-0.00068015552, -6.4322277e-05) (-0.00068034628, -6.3560723e-05) (-0.00068046148, -6.2784137e-05) (-0.0006805, -6.2e-05) (-0.0006805, 6.2e-05) (-0.00068046148, 6.2784137e-05) (-0.00068034628, 6.3560723e-05) (-0.00068015552, 6.4322277e-05) (-0.00067989104, 6.5061467e-05) (-0.00067955537, 6.5771174e-05) (-0.00067915176, 6.6444562e-05) (-0.00067868408, 6.7075146e-05) (-0.00067815685, 6.7656854e-05) (-0.00067757515, 6.8184084e-05) (-0.00067694456, 6.8651757e-05) (-0.00067627117, 6.905537e-05) (-0.00067556147, 6.9391036e-05) (-0.00067482228, 6.9655523e-05) (-0.00067406072, 6.9846282e-05) (-0.00067328414, 6.9961478e-05) (-0.0006725, 7e-05) (-0.0006475, 7e-05) (-0.00064671586, 6.9961478e-05) (-0.00064593928, 6.9846282e-05) (-0.00064517772, 6.9655523e-05) (-0.00064443853, 6.9391036e-05) (-0.00064372883, 6.905537e-05) (-0.00064305544, 6.8651757e-05) (-0.00064242485, 6.8184084e-05) (-0.00064184315, 6.7656854e-05) (-0.00064131592, 6.7075146e-05) (-0.00064084824, 6.6444562e-05) (-0.00064044463, 6.5771174e-05) (-0.00064010896, 6.5061467e-05) (-0.00063984448, 6.4322277e-05) (-0.00063965372, 6.3560723e-05) (-0.00063953852, 6.2784137e-05) (-0.0006395, 6.2e-05) (-0.0006395, -6.2e-05) (-0.00063953852, -6.2784137e-05) (-0.00063965372, -6.3560723e-05) (-0.00063984448, -6.4322277e-05) (-0.00064010896, -6.5061467e-05) (-0.00064044463, -6.5771174e-05) (-0.00064084824, -6.6444562e-05) (-0.00064131592, -6.7075146e-05) (-0.00064184315, -6.7656854e-05) (-0.00064242485, -6.8184084e-05) (-0.00064305544, -6.8651757e-05) (-0.00064372883, -6.905537e-05) (-0.00064443853, -6.9391036e-05) (-0.00064517772, -6.9655523e-05) (-0.00064593928, -6.9846282e-05) (-0.00064671586, -6.9961478e-05) (-0.0006475, -7e-05) (-0.0006725, -7e-05), closed, covered)
  frame_cin = polyline(z=0, xy: (-0.0006885, -7e-05) (-0.00068846148, -7.0784137e-05) (-0.00068834628, -7.1560723e-05) (-0.00068815552, -7.2322277e-05) (-0.00068789104, -7.3061467e-05) (-0.00068755537, -7.3771174e-05) (-0.00068715176, -7.4444562e-05) (-0.00068668408, -7.5075146e-05) (-0.00068615685, -7.5656854e-05) (-0.00068557515, -7.6184084e-05) (-0.00068494456, -7.6651757e-05) (-0.00068427117, -7.705537e-05) (-0.00068356147, -7.7391036e-05) (-0.00068282228, -7.7655523e-05) (-0.00068206072, -7.7846282e-05) (-0.00068128414, -7.7961478e-05) (-0.0006805, -7.8e-05) (-0.0006395, -7.8e-05) (-0.00063871586, -7.7961478e-05) (-0.00063793928, -7.7846282e-05) (-0.00063717772, -7.7655523e-05) (-0.00063643853, -7.7391036e-05) (-0.00063572883, -7.705537e-05) (-0.00063505544, -7.6651757e-05) (-0.00063442485, -7.6184084e-05) (-0.00063384315, -7.5656854e-05) (-0.00063331592, -7.5075146e-05) (-0.00063284824, -7.4444562e-05) (-0.00063244463, -7.3771174e-05) (-0.00063210896, -7.3061467e-05) (-0.00063184448, -7.2322277e-05) (-0.00063165372, -7.1560723e-05) (-0.00063153852, -7.0784137e-05) (-0.0006315, -7e-05) (-0.0006315, -1.909818e-05) (-0.00063149518, -1.8901939e-05) (-0.00063147111, -1.8412015e-05) (-0.00063143266, -1.80216e-05) (-0.0006313751, -1.7633541e-05) (-0.00063129856, -1.7248774e-05) (-0.00063120324, -1.6868226e-05) (-0.00063108936, -1.6492814e-05) (-0.0006309572, -1.6123441e-05) (-0.00063080707, -1.5760999e-05) (-0.00063063934, -1.540636e-05) (-0.00063045441, -1.5060378e-05) (-0.00063025272, -1.4723887e-05) (-0.00063003477, -1.4397697e-05) (-0.00062980107, -1.4082595e-05) (-0.0006295522, -1.3779339e-05) (-0.00062928874, -1.348866e-05) (-0.00062901134, -1.3211259e-05) (-0.00062872066, -1.2947803e-05) (-0.00062841741, -1.2698928e-05) (-0.0006281023, -1.2465232e-05) (-0.00062777611, -1.2247279e-05) (-0.00062743962, -1.2045594e-05) (-0.00062709364, -1.1860663e-05) (-0.000626739, -1.1692931e-05) (-0.00062637656, -1.1542802e-05) (-0.00062600719, -1.1410639e-05) (-0.00062563177, -1.1296759e-05) (-0.00062525123, -1.1201436e-05) (-0.00062486646, -1.1124902e-05) (-0.0006244784, -1.1067338e-05) (-0.00062408799, -1.1028886e-05) (-0.00062359806, -1.1004817e-05) (-0.00062340182, -1.1e-05) (-0.00057559818, -1.1e-05) (-0.00057540194, -1.1004817e-05) (-0.00057491201, -1.1028886e-05) (-0.0005745216, -1.1067338e-05) (-0.00057413354, -1.1124902e-05) (-0.00057374877, -1.1201436e-05) (-0.00057336823, -1.1296759e-05) (-0.00057299281, -1.1410639e-05) (-0.00057262344, -1.1542802e-05) (-0.000572261, -1.1692931e-05) (-0.00057190636, -1.1860663e-05) (-0.00057156038, -1.2045594e-05) (-0.00057122389, -1.2247279e-05) (-0.0005708977, -1.2465232e-05) (-0.0005705826, -1.2698928e-05) (-0.00057027934, -1.2947803e-05) (-0.00056998866, -1.3211259e-05) (-0.00056971126, -1.348866e-05) (-0.0005694478, -1.3779339e-05) (-0.00056919893, -1.4082595e-05) (-0.00056896523, -1.4397697e-05) (-0.00056874728, -1.4723887e-05) (-0.00056854559, -1.5060378e-05) (-0.00056836066, -1.540636e-05) (-0.00056819293, -1.5760999e-05) (-0.0005680428, -1.6123441e-05) (-0.00056791064, -1.6492814e-05) (-0.00056779676, -1.6868226e-05) (-0.00056770144, -1.7248774e-05) (-0.0005676249, -1.7633541e-05) (-0.00056756734, -1.80216e-05) (-0.00056752889, -1.8412015e-05) (-0.00056750482, -1.8901939e-05) (-0.0005675, -1.909818e-05) (-0.0005675, -0.00012690182) (-0.00056750482, -0.00012709806) (-0.00056752889, -0.00012758798) (-0.00056756734, -0.0001279784) (-0.0005676249, -0.00012836646) (-0.00056770144, -0.00012875123) (-0.00056779676, -0.00012913177) (-0.00056791064, -0.00012950719) (-0.0005680428, -0.00012987656) (-0.00056819293, -0.000130239) (-0.00056836066, -0.00013059364) (-0.00056854559, -0.00013093962) (-0.00056874728, -0.00013127611) (-0.00056896523, -0.0001316023) (-0.00056919893, -0.00013191741) (-0.0005694478, -0.00013222066) (-0.00056971126, -0.00013251134) (-0.00056998866, -0.00013278874) (-0.00057027934, -0.0001330522) (-0.0005705826, -0.00013330107) (-0.0005708977, -0.00013353477) (-0.00057122389, -0.00013375272) (-0.00057156038, -0.00013395441) (-0.00057190636, -0.00013413934) (-0.000572261, -0.00013430707) (-0.00057262344, -0.0001344572) (-0.00057299281, -0.00013458936) (-0.00057336823, -0.00013470324) (-0.00057374877, -0.00013479856) (-0.00057413354, -0.0001348751) (-0.0005745216, -0.00013493266) (-0.00057491201, -0.00013497111) (-0.00057540194, -0.00013499518) (-0.00057559818, -0.000135) (-0.00073240182, -0.000135) (-0.00073259806, -0.00013499518) (-0.00073308798, -0.00013497111) (-0.0007334784, -0.00013493266) (-0.00073386646, -0.0001348751) (-0.00073425123, -0.00013479856) (-0.00073463177, -0.00013470324) (-0.00073500719, -0.00013458936) (-0.00073537656, -0.0001344572) (-0.000735739, -0.00013430707) (-0.00073609364, -0.00013413934) (-0.00073643962, -0.00013395441) (-0.00073677611, -0.00013375272) (-0.0007371023, -0.00013353477) (-0.0007374174, -0.00013330107) (-0.00073772066, -0.0001330522) (-0.00073801134, -0.00013278874) (-0.00073828874, -0.00013251134) (-0.0007385522, -0.00013222066) (-0.00073880107, -0.00013191741) (-0.00073903477, -0.0001316023) (-0.00073925272, -0.00013127611) (-0.00073945441, -0.00013093962) (-0.00073963934, -0.00013059364) (-0.00073980707, -0.000130239) (-0.0007399572, -0.00012987656) (-0.00074008936, -0.00012950719) (-0.00074020324, -0.00012913177) (-0.00074029856, -0.00012875123) (-0.0007403751, -0.00012836646) (-0.00074043266, -0.0001279784) (-0.00074047111, -0.00012758798) (-0.00074049518, -0.00012709806) (-0.0007405, -0.00012690182) (-0.0007405, 0.00012690182) (-0.00074049518, 0.00012709806) (-0.00074047111, 0.00012758798) (-0.00074043266, 0.0001279784) (-0.0007403751, 0.00012836646) (-0.00074029856, 0.00012875123) (-0.00074020324, 0.00012913177) (-0.00074008936, 0.00012950719) (-0.0007399572, 0.00012987656) (-0.00073980707, 0.000130239) (-0.00073963934, 0.00013059364) (-0.00073945441, 0.00013093962) (-0.00073925272, 0.00013127611) (-0.00073903477, 0.0001316023) (-0.00073880107, 0.00013191741) (-0.0007385522, 0.00013222066) (-0.00073828874, 0.00013251134) (-0.00073801134, 0.00013278874) (-0.00073772066, 0.0001330522) (-0.0007374174, 0.00013330107) (-0.0007371023, 0.00013353477) (-0.00073677611, 0.00013375272) (-0.00073643962, 0.00013395441) (-0.00073609364, 0.00013413934) (-0.000735739, 0.00013430707) (-0.00073537656, 0.0001344572) (-0.00073500719, 0.00013458936) (-0.00073463177, 0.00013470324) (-0.00073425123, 0.00013479856) (-0.00073386646, 0.0001348751) (-0.0007334784, 0.00013493266) (-0.00073308798, 0.00013497111) (-0.00073259806, 0.00013499518) (-0.00073240182, 0.000135) (-0.00057559818, 0.000135) (-0.00057540194, 0.00013499518) (-0.00057491201, 0.00013497111) (-0.0005745216, 0.00013493266) (-0.00057413354, 0.0001348751) (-0.00057374877, 0.00013479856) (-0.00057336823, 0.00013470324) (-0.00057299281, 0.00013458936) (-0.00057262344, 0.0001344572) (-0.000572261, 0.00013430707) (-0.00057190636, 0.00013413934) (-0.00057156038, 0.00013395441) (-0.00057122389, 0.00013375272) (-0.0005708977, 0.00013353477) (-0.0005705826, 0.00013330107) (-0.00057027934, 0.0001330522) (-0.00056998866, 0.00013278874) (-0.00056971126, 0.00013251134) (-0.0005694478, 0.00013222066) (-0.00056919893, 0.00013191741) (-0.00056896523, 0.0001316023) (-0.00056874728, 0.00013127611) (-0.00056854559, 0.00013093962) (-0.00056836066, 0.00013059364) (-0.00056819293, 0.000130239) (-0.0005680428, 0.00012987656) (-0.00056791064, 0.00012950719) (-0.00056779676, 0.00012913177) (-0.00056770144, 0.00012875123) (-0.0005676249, 0.00012836646) (-0.00056756734, 0.0001279784) (-0.00056752889, 0.00012758798) (-0.00056750482, 0.00012709806) (-0.0005675, 0.00012690182) (-0.0005675, 1.909818e-05) (-0.00056750482, 1.8901939e-05) (-0.00056752889, 1.8412015e-05) (-0.00056756734, 1.80216e-05) (-0.0005676249, 1.7633541e-05) (-0.00056770144, 1.7248774e-05) (-0.00056779676, 1.6868226e-05) (-0.00056791064, 1.6492814e-05) (-0.0005680428, 1.6123441e-05) (-0.00056819293, 1.5760999e-05) (-0.00056836066, 1.540636e-05) (-0.00056854559, 1.5060378e-05) (-0.00056874728, 1.4723887e-05) (-0.00056896523, 1.4397697e-05) (-0.00056919893, 1.4082595e-05) (-0.0005694478, 1.3779339e-05) (-0.00056971126, 1.348866e-05) (-0.00056998866, 1.3211259e-05) (-0.00057027934, 1.2947803e-05) (-0.0005705826, 1.2698928e-05) (-0.0005708977, 1.2465232e-05) (-0.00057122389, 1.2247279e-05) (-0.00057156038, 1.2045594e-05) (-0.00057190636, 1.1860663e-05) (-0.000572261, 1.1692931e-05) (-0.00057262344, 1.1542802e-05) (-0.00057299281, 1.1410639e-05) (-0.00057336823, 1.1296759e-05) (-0.00057374877, 1.1201436e-05) (-0.00057413354, 1.1124902e-05) (-0.0005745216, 1.1067338e-05) (-0.00057491201, 1.1028886e-05) (-0.00057540194, 1.1004817e-05) (-0.00057559818, 1.1e-05) (-0.00062340182, 1.1e-05) (-0.00062359806, 1.1004817e-05) (-0.00062408799, 1.1028886e-05) (-0.0006244784, 1.1067338e-05) (-0.00062486646, 1.1124902e-05) (-0.00062525123, 1.1201436e-05) (-0.00062563177, 1.1296759e-05) (-0.00062600719, 1.1410639e-05) (-0.00062637656, 1.1542802e-05) (-0.000626739, 1.1692931e-05) (-0.00062709364, 1.1860663e-05) (-0.00062743962, 1.2045594e-05) (-0.00062777611, 1.2247279e-05) (-0.0006281023, 1.2465232e-05) (-0.00062841741, 1.2698928e-05) (-0.00062872066, 1.2947803e-05) (-0.00062901134, 1.3211259e-05) (-0.00062928874, 1.348866e-05) (-0.0006295522, 1.3779339e-05) (-0.00062980107, 1.4082595e-05) (-0.00063003477, 1.4397697e-05) (-0.00063025272, 1.4723887e-05) (-0.00063045441, 1.5060378e-05) (-0.00063063934, 1.540636e-05) (-0.00063080707, 1.5760999e-05) (-0.0006309572, 1.6123441e-05) (-0.00063108936, 1.6492814e-05) (-0.00063120324, 1.6868226e-05)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, closed, covered)
  pocket_cin = polyline(z=0, xy: (-0.0007525, -0.000135) (-0.0007525, 0.000135) (-0.00075244222, 0.00013617621) (-0.00075226942, 0.00013734108) (-0.00075198328, 0.00013848342) (-0.00075158655, 0.0001395922) (-0.00075108306, 0.00014065676) (-0.00075047764, 0.00014166684) (-0.00074977613, 0.00014261272) (-0.00074898528, 0.00014348528) (-0.00074811272, 0.00014427613) (-0.00074716684, 0.00014497764) (-0.00074615676, 0.00014558305) (-0.0007450922, 0.00014608655) (-0.00074398342, 0.00014648328) (-0.00074284108, 0.00014676942) (-0.00074167621, 0.00014694222) (-0.0007405, 0.000147) (-0.0005675, 0.000147) (-0.00056632379, 0.00014694222) (-0.00056515892, 0.00014676942) (-0.00056401658, 0.00014648328) (-0.0005629078, 0.00014608655) (-0.00056184324, 0.00014558305) (-0.00056083316, 0.00014497764) (-0.00055988728, 0.00014427613) (-0.00055901472, 0.00014348528) (-0.00055822388, 0.00014261272) (-0.00055752237, 0.00014166684) (-0.00055691694, 0.00014065676) (-0.00055641345, 0.0001395922) (-0.00055601672, 0.00013848342) (-0.00055573058, 0.00013734108) (-0.00055555778, 0.00013617621) (-0.0005555, 0.000135) (-0.0005555, -0.000135) (-0.00055555778, -0.00013617621) (-0.00055573058, -0.00013734108) (-0.00055601672, -0.00013848342) (-0.00055641345, -0.0001395922) (-0.00055691694, -0.00014065676) (-0.00055752237, -0.00014166684) (-0.00055822388, -0.00014261272) (-0.00055901472, -0.00014348528) (-0.00055988728, -0.00014427613) (-0.00056083316, -0.00014497764) (-0.00056184324, -0.00014558305) (-0.0005629078, -0.00014608655) (-0.00056401658, -0.00014648328) (-0.00056515892, -0.00014676942) (-0.00056632379, -0.00014694222) (-0.0005675, -0.000147) (-0.0007405, -0.000147) (-0.00074167621, -0.00014694222) (-0.00074284108, -0.00014676942) (-0.00074398342, -0.00014648328) (-0.0007450922, -0.00014608655) (-0.00074615676, -0.00014558305) (-0.00074716684, -0.00014497764) (-0.00074811272, -0.00014427613) (-0.00074898528, -0.00014348528) (-0.00074977613, -0.00014261272) (-0.00075047764, -0.00014166684) (-0.00075108306, -0.00014065676) (-0.00075158655, -0.0001395922) (-0.00075198328, -0.00013848342) (-0.00075226942, -0.00013734108) (-0.00075244222, -0.00013617621) (-0.0007525, -0.000135), closed, covered)
  tap_trace_n0 = polyline(z=0, xy: (0.00015, -5e-06) (-0.00015, -5e-06) (-0.00015, 5e-06) (-5e-06, 5e-06) (-5e-06, 0.0001) (5e-06, 0.0001) (5e-06, 5e-06) (0.00015, 5e-06) (0.00015, -5e-06), closed, covered)
  tap_cut_n0 = polyline(z=0, xy: (0.00015, -1.1e-05) (-0.00015, -1.1e-05) (-0.00015, 1.1e-05) (-1.1e-05, 1.1e-05) (-1.1e-05, 0.0001) (1.1e-05, 0.0001) (1.1e-05, 1.1e-05) (0.00015, 1.1e-05) (0.00015, -1.1e-05), closed, covered)
  plate_cp = polyline(z=0, xy: (7e-05, 0.00027) (6.9961478e-05, 0.00026921586) (6.9846282e-05, 0.00026843928) (6.9655523e-05, 0.00026767772) (6.9391036e-05, 0.00026693853) (6.905537e-05, 0.00026622883) (6.8651757e-05, 0.00026555544) (6.8184084e-05, 0.00026492485) (6.7656854e-05, 0.00026434315) (6.7075146e-05, 0.00026381592) (6.6444562e-05, 0.00026334824) (6.5771174e-05, 0.00026294463) (6.5061467e-05, 0.00026260896) (6.4322277e-05, 0.00026234448) (6.3560723e-05, 0.00026215372) (6.2784137e-05, 0.00026203852) (6.2e-05, 0.000262) (-6.2e-05, 0.000262) (-6.2784137e-05, 0.00026203852) (-6.3560723e-05, 0.00026215372) (-6.4322277e-05, 0.00026234448) (-6.5061467e-05, 0.00026260896) (-6.5771174e-05, 0.00026294463) (-6.6444562e-05, 0.00026334824) (-6.7075146e-05, 0.00026381592) (-6.7656854e-05, 0.00026434315) (-6.8184084e-05, 0.00026492485) (-6.8651757e-05, 0.00026555544) (-6.905537e-05, 0.00026622883) (-6.9391036e-05, 0.00026693853) (-6.9655523e-05, 0.00026767772) (-6.9846282e-05, 0.00026843928) (-6.9961478e-05, 0.00026921586) (-7e-05, 0.00027) (-7e-05, 0.000295) (-6.9961478e-05, 0.00029578414) (-6.9846282e-05, 0.00029656072) (-6.9655523e-05, 0.00029732228) (-6.9391036e-05, 0.00029806147) (-6.905537e-05, 0.00029877117) (-6.8651757e-05, 0.00029944456) (-6.8184084e-05, 0.00030007515) (-6.7656854e-05, 0.00030065685) (-6.7075146e-05, 0.00030118408) (-6.6444562e-05, 0.00030165176) (-6.5771174e-05, 0.00030205537) (-6.5061467e-05, 0.00030239104) (-6.4322277e-05, 0.00030265552) (-6.3560723e-05, 0.00030284628) (-6.2784137e-05, 0.00030296148) (-6.2e-05, 0.000303) (6.2e-05, 0.000303) (6.2784137e-05, 0.00030296148) (6.3560723e-05, 0.00030284628) (6.4322277e-05, 0.00030265552) (6.5061467e-05, 0.00030239104) (6.5771174e-05, 0.00030205537) (6.6444562e-05, 0.00030165176) (6.7075146e-05, 0.00030118408) (6.7656854e-05, 0.00030065685) (6.8184084e-05, 0.00030007515) (6.8651757e-05, 0.00029944456) (6.905537e-05, 0.00029877117) (6.9391036e-05, 0.00029806147) (6.9655523e-05, 0.00029732228) (6.9846282e-05, 0.00029656072) (6.9961478e-05, 0.00029578414) (7e-05, 0.000295) (7e-05, 0.00027), closed, covered)
  frame_cp = polyline(z=0, xy: (7e-05, 0.000254) (7.0784137e-05, 0.00025403852) (7.1560723e-05, 0.00025415372) (7.2322277e-05, 0.00025434448) (7.3061467e-05, 0.00025460896) (7.3771174e-05, 0.00025494463) (7.4444562e-05, 0.00025534824) (7.5075146e-05, 0.00025581592) (7.5656854e-05, 0.00025634315) (7.6184084e-05, 0.00025692485) (7.6651757e-05, 0.00025755544) (7.705537e-05, 0.00025822883) (7.7391036e-05, 0.00025893853) (7.7655523e-05, 0.00025967772) (7.7846282e-05, 0.00026043928) (7.7961478e-05, 0.00026121586) (7.8e-05, 0.000262) (7.8e-05, 0.000303) (7.7961478e-05, 0.00030378414) (7.7846282e-05, 0.00030456072) (7.7655523e-05, 0.00030532228) (7.7391036e-05, 0.00030606147) (7.705537e-05, 0.00030677117) (7.6651757e-05, 0.00030744456) (7.6184084e-05, 0.00030807515) (7.5656854e-05, 0.00030865685) (7.5075146e-05, 0.00030918408) (7.4444562e-05, 0.00030965176) (7.3771174e-05, 0.00031005537) (7.3061467e-05, 0.00031039104) (7.2322277e-05, 0.00031065552) (7.1560723e-05, 0.00031084628) (7.0784137e-05, 0.00031096148) (7e-05, 0.000311) (1.909818e-05, 0.000311) (1.8901939e-05, 0.00031100482) (1.8412015e-05, 0.00031102889) (1.80216e-05, 0.00031106734) (1.7633541e-05, 0.0003111249) (1.7248774e-05, 0.00031120144) (1.6868226e-05, 0.00031129676) (1.6492814e-05, 0.00031141064) (1.6123441e-05, 0.0003115428) (1.5760999e-05, 0.00031169293) (1.540636e-05, 0.00031186066) (1.5060378e-05, 0.00031204559) (1.4723887e-05, 0.00031224728) (1.4397697e-05, 0.00031246523) (1.4082595e-05, 0.00031269893) (1.3779339e-05, 0.0003129478) (1.348866e-05, 0.00031321126) (1.3211259e-05, 0.00031348866) (1.2947803e-05, 0.00031377934) (1.2698928e-05, 0.00031408259) (1.2465232e-05, 0.0003143977) (1.2247279e-05, 0.00031472389) (1.2045594e-05, 0.00031506038) (1.1860663e-05, 0.00031540636) (1.1692931e-05, 0.000315761) (1.1542802e-05, 0.00031612344) (1.1410639e-05, 0.00031649281) (1.1296759e-05, 0.00031686823) (1.1201436e-05, 0.00031724877) (1.1124902e-05, 0.00031763354) (1.1067338e-05, 0.0003180216) (1.1028886e-05, 0.00031841202) (1.1004817e-05, 0.00031890194) (1.1e-05, 0.00031909818) (1.1e-05, 0.00036690182) (1.1004817e-05, 0.00036709806) (1.1028886e-05, 0.00036758799) (1.1067338e-05, 0.0003679784) (1.1124902e-05, 0.00036836646) (1.1201436e-05, 0.00036875123) (1.1296759e-05, 0.00036913177) (1.1410639e-05, 0.00036950719) (1.1542802e-05, 0.00036987656) (1.1692931e-05, 0.000370239) (1.1860663e-05, 0.00037059364) (1.2045594e-05, 0.00037093962) (1.2247279e-05, 0.00037127611) (1.2465232e-05, 0.0003716023) (1.2698928e-05, 0.0003719174) (1.2947803e-05, 0.00037222066) (1.3211259e-05, 0.00037251134) (1.348866e-05, 0.00037278874) (1.3779339e-05, 0.0003730522) (1.4082595e-05, 0.00037330107) (1.4397697e-05, 0.00037353477) (1.4723887e-05, 0.00037375272) (1.5060378e-05, 0.00037395441) (1.540636e-05, 0.00037413934) (1.5760999e-05, 0.00037430707) (1.6123441e-05, 0.0003744572) (1.6492814e-05, 0.00037458936) (1.6868226e-05, 0.00037470324) (1.7248774e-05, 0.00037479856) (1.7633541e-05, 0.0003748751) (1.80216e-05, 0.00037493266) (1.8412015e-05, 0.00037497111) (1.8901939e-05, 0.00037499518) (1.909818e-05, 0.000375) (0.00012690182, 0.000375) (0.00012709806, 0.00037499518) (0.00012758798, 0.00037497111) (0.0001279784, 0.00037493266) (0.00012836646, 0.0003748751) (0.00012875123, 0.00037479856) (0.00012913177, 0.00037470324) (0.00012950719, 0.00037458936) (0.00012987656, 0.0003744572) (0.000130239, 0.00037430707) (0.00013059364, 0.00037413934) (0.00013093962, 0.00037395441) (0.00013127611, 0.00037375272) (0.0001316023, 0.00037353477) (0.00013191741, 0.00037330107) (0.00013222066, 0.0003730522) (0.00013251134, 0.00037278874) (0.00013278874, 0.00037251134) (0.0001330522, 0.00037222066) (0.00013330107, 0.0003719174) (0.00013353477, 0.0003716023) (0.00013375272, 0.00037127611) (0.00013395441, 0.00037093962) (0.00013413934, 0.00037059364) (0.00013430707, 0.000370239) (0.0001344572, 0.00036987656) (0.00013458936, 0.00036950719) (0.00013470324, 0.00036913177) (0.00013479856, 0.00036875123) (0.0001348751, 0.00036836646) (0.00013493266, 0.0003679784) (0.00013497111, 0.00036758799) (0.00013499518, 0.00036709806) (0.000135, 0.00036690182) (0.000135, 0.00021009818) (0.00013499518, 0.00020990194) (0.00013497111, 0.00020941201) (0.00013493266, 0.0002090216) (0.0001348751, 0.00020863354) (0.00013479856, 0.00020824877) (0.00013470324, 0.00020786823) (0.00013458936, 0.00020749281) (0.0001344572, 0.00020712344) (0.00013430707, 0.000206761) (0.00013413934, 0.00020640636) (0.00013395441, 0.00020606038) (0.00013375272, 0.00020572389) (0.00013353477, 0.0002053977) (0.00013330107, 0.00020508259) (0.0001330522, 0.00020477934) (0.00013278874, 0.00020448866) (0.00013251134, 0.00020421126) (0.00013222066, 0.0002039478) (0.00013191741, 0.00020369893) (0.0001316023, 0.00020346523) (0.00013127611, 0.00020324728) (0.00013093962, 0.00020304559) (0.00013059364, 0.00020286066) (0.000130239, 0.00020269293) (0.00012987656, 0.0002025428) (0.00012950719, 0.00020241064) (0.00012913177, 0.00020229676) (0.00012875123, 0.00020220144) (0.00012836646, 0.0002021249) (0.0001279784, 0.00020206734) (0.00012758798, 0.00020202889) (0.00012709806, 0.00020200482) (0.00012690182, 0.000202) (-0.00012690182, 0.000202) (-0.00012709806, 0.00020200482) (-0.00012758798, 0.00020202889) (-0.0001279784, 0.00020206734) (-0.00012836646, 0.0002021249) (-0.00012875123, 0.00020220144) (-0.00012913177, 0.00020229676) (-0.00012950719, 0.00020241064) (-0.00012987656, 0.0002025428) (-0.000130239, 0.00020269293) (-0.00013059364, 0.00020286066) (-0.00013093962, 0.00020304559) (-0.00013127611, 0.00020324728) (-0.0001316023, 0.00020346523) (-0.00013191741, 0.00020369893) (-0.00013222066, 0.0002039478) (-0.00013251134, 0.00020421126) (-0.00013278874, 0.00020448866) (-0.0001330522, 0.00020477934) (-0.00013330107, 0.00020508259) (-0.00013353477, 0.0002053977) (-0.00013375272, 0.00020572389) (-0.00013395441, 0.00020606038) (-0.00013413934, 0.00020640636) (-0.00013430707, 0.000206761) (-0.0001344572, 0.00020712344) (-0.00013458936, 0.00020749281) (-0.00013470324, 0.00020786823) (-0.00013479856, 0.00020824877) (-0.0001348751, 0.00020863354) (-0.00013493266, 0.0002090216) (-0.00013497111, 0.00020941201) (-0.00013499518, 0.00020990194) (-0.000135, 0.00021009818) (-0.000135, 0.00036690182) (-0.00013499518, 0.00036709806) (-0.00013497111, 0.00036758799) (-0.00013493266, 0.0003679784) (-0.0001348751, 0.00036836646) (-0.00013479856, 0.00036875123) (-0.00013470324, 0.00036913177) (-0.00013458936, 0.00036950719) (-0.0001344572, 0.00036987656) (-0.00013430707, 0.000370239) (-0.00013413934, 0.00037059364) (-0.00013395441, 0.00037093962) (-0.00013375272, 0.00037127611) (-0.00013353477, 0.0003716023) (-0.00013330107, 0.0003719174) (-0.0001330522, 0.00037222066) (-0.00013278874, 0.00037251134) (-0.00013251134, 0.00037278874) (-0.00013222066, 0.0003730522) (-0.00013191741, 0.00037330107) (-0.0001316023, 0.00037353477) (-0.00013127611, 0.00037375272) (-0.00013093962, 0.00037395441) (-0.00013059364, 0.00037413934) (-0.000130239, 0.00037430707) (-0.00012987656, 0.0003744572) (-0.00012950719, 0.00037458936) (-0.00012913177, 0.00037470324) (-0.00012875123, 0.00037479856) (-0.00012836646, 0.0003748751) (-0.0001279784, 0.00037493266) (-0.00012758798, 0.00037497111) (-0.00012709806, 0.00037499518) (-0.00012690182, 0.000375) (-1.909818e-05, 0.000375) (-1.8901939e-05, 0.00037499518) (-1.8412015e-05, 0.00037497111) (-1.80216e-05, 0.00037493266) (-1.7633541e-05, 0.0003748751) (-1.7248774e-05, 0.00037479856) (-1.6868226e-05, 0.00037470324) (-1.6492814e-05, 0.00037458936) (-1.6123441e-05, 0.0003744572) (-1.5760999e-05, 0.00037430707) (-1.540636e-05, 0.00037413934) (-1.5060378e-05, 0.00037395441) (-1.4723887e-05, 0.00037375272) (-1.4397697e-05, 0.00037353477) (-1.4082595e-05, 0.00037330107) (-1.3779339e-05, 0.0003730522) (-1.348866e-05, 0.00037278874) (-1.3211259e-05, 0.00037251134) (-1.2947803e-05, 0.00037222066) (-1.2698928e-05, 0.0003719174) (-1.2465232e-05, 0.0003716023) (-1.2247279e-05, 0.00037127611) (-1.2045594e-05, 0.00037093962) (-1.1860663e-05, 0.00037059364) (-1.1692931e-05, 0.000370239) (-1.1542802e-05, 0.00036987656) (-1.1410639e-05, 0.00036950719) (-1.1296759e-05, 0.00036913177) (-1.1201436e-05, 0.00036875123) (-1.1124902e-05, 0.00036836646) (-1.1067338e-05, 0.0003679784) (-1.1028886e-05, 0.00036758799) (-1.1004817e-05, 0.00036709806) (-1.1e-05, 0.00036690182) (-1.1e-05, 0.00031909818) (-1.1004817e-05, 0.00031890194) (-1.1028886e-05, 0.00031841202) (-1.1067338e-05, 0.0003180216) (-1.1124902e-05, 0.00031763354) (-1.1201436e-05, 0.00031724877) (-1.1296759e-05, 0.00031686823) (-1.1410639e-05, 0.00031649281) (-1.1542802e-05, 0.00031612344) (-1.1692931e-05, 0.000315761) (-1.1860663e-05, 0.00031540636) (-1.2045594e-05, 0.00031506038) (-1.2247279e-05, 0.00031472389) (-1.2465232e-05, 0.0003143977) (-1.2698928e-05, 0.00031408259) (-1.2947803e-05, 0.00031377934) (-1.3211259e-05, 0.00031348866) (-1.348866e-05, 0.00031321126) (-1.3779339e-05, 0.0003129478) (-1.4082595e-05, 0.00031269893) (-1.4397697e-05, 0.00031246523) (-1.4723887e-05, 0.00031224728) (-1.5060378e-05, 0.00031204559) (-1.540636e-05, 0.00031186066) (-1.5760999e-05, 0.00031169293) (-1.6123441e-05, 0.0003115428) (-1.6492814e-05, 0.00031141064) (-1.6868226e-05, 0.00031129676)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, closed, covered)
  pocket_cp = polyline(z=0, xy: (0.000135, 0.00019) (-0.000135, 0.00019) (-0.00013617621, 0.00019005778) (-0.00013734108, 0.00019023058) (-0.00013848342, 0.00019051672) (-0.0001395922, 0.00019091345) (-0.00014065676, 0.00019141694) (-0.00014166684, 0.00019202237) (-0.00014261272, 0.00019272388) (-0.00014348528, 0.00019351472) (-0.00014427613, 0.00019438728) (-0.00014497764, 0.00019533316) (-0.00014558305, 0.00019634324) (-0.00014608655, 0.0001974078) (-0.00014648328, 0.00019851658) (-0.00014676942, 0.00019965892) (-0.00014694222, 0.00020082379) (-0.000147, 0.000202) (-0.000147, 0.000375) (-0.00014694222, 0.00037617621) (-0.00014676942, 0.00037734108) (-0.00014648328, 0.00037848342) (-0.00014608655, 0.0003795922) (-0.00014558305, 0.00038065676) (-0.00014497764, 0.00038166684) (-0.00014427613, 0.00038261272) (-0.00014348528, 0.00038348528) (-0.00014261272, 0.00038427613) (-0.00014166684, 0.00038497764) (-0.00014065676, 0.00038558305) (-0.0001395922, 0.00038608655) (-0.00013848342, 0.00038648328) (-0.00013734108, 0.00038676942) (-0.00013617621, 0.00038694222) (-0.000135, 0.000387) (0.000135, 0.000387) (0.00013617621, 0.00038694222) (0.00013734108, 0.00038676942) (0.00013848342, 0.00038648328) (0.0001395922, 0.00038608655) (0.00014065676, 0.00038558305) (0.00014166684, 0.00038497764) (0.00014261272, 0.00038427613) (0.00014348528, 0.00038348528) (0.00014427613, 0.00038261272) (0.00014497764, 0.00038166684) (0.00014558305, 0.00038065676) (0.00014608655, 0.0003795922) (0.00014648328, 0.00037848342) (0.00014676942, 0.00037734108) (0.00014694222, 0.00037617621) (0.000147, 0.000375) (0.000147, 0.000202) (0.00014694222, 0.00020082379) (0.00014676942, 0.00019965892) (0.00014648328, 0.00019851658) (0.00014608655, 0.0001974078) (0.00014558305, 0.00019634324) (0.00014497764, 0.00019533316) (0.00014427613, 0.00019438728) (0.00014348528, 0.00019351472) (0.00014261272, 0.00019272388) (0.00014166684, 0.00019202237) (0.00014065676, 0.00019141694) (0.0001395922, 0.00019091345) (0.00013848342, 0.00019051672) (0.00013734108, 0.00019023058) (0.00013617621, 0.00019005778) (0.000135, 0.00019), closed, covered)
  tap_trace_jf = polyline(z=0, xy: (-5e-06, 0.001465) (-5e-06, 0.001765) (5e-06, 0.001765) (5e-06, 0.00162) (7.55e-05, 0.00162) (7.55e-05, 0.00161) (5e-06, 0.00161) (5e-06, 0.001465) (-5e-06, 0.001465), closed, covered)
  tap_cut_jf = polyline(z=0, xy: (-1.1e-05, 0.001465) (-1.1e-05, 0.001765) (1.1e-05, 0.001765) (1.1e-05, 0.001626) (7.55e-05, 0.001626) (7.55e-05, 0.001604) (1.1e-05, 0.001604) (1.1e-05, 0.001465) (-1.1e-05, 0.001465), closed, covered)
  tap_trace_jr = polyline(z=0, xy: (0.0001745, 0.00162) (0.000245, 0.00162) (0.000245, 0.001765) (0.000255, 0.001765) (0.000255, 0.001465) (0.000245, 0.001465) (0.000245, 0.00161) (0.0001745, 0.00161) (0.0001745, 0.00162), closed, covered)
  tap_cut_jr = polyline(z=0, xy: (0.0001745, 0.001626) (0.000239, 0.001626) (0.000239, 0.001765) (0.000261, 0.001765) (0.000261, 0.001465) (0.000239, 0.001465) (0.000239, 0.001604) (0.0001745, 0.001604) (0.0001745, 0.001626), closed, covered)
  head_a_cj = polyline(z=0, xy: (0.0001075, 0.001596) (0.00010730397, 0.0015960096) (0.00010710982, 0.0015960384) (0.00010691943, 0.0015960861) (0.00010673463, 0.0015961522) (0.00010655721, 0.0015962362) (0.00010638886, 0.0015963371) (0.00010623121, 0.001596454) (0.00010608579, 0.0015965858) (0.00010595398, 0.0015967312) (0.00010583706, 0.0015968889) (0.00010573616, 0.0015970572) (0.00010565224, 0.0015972346) (0.00010558612, 0.0015974194) (0.00010553843, 0.0015976098) (0.00010550963, 0.001597804) (0.0001055, 0.001598) (0.0001055, 0.001632) (0.00010550963, 0.001632196) (0.00010553843, 0.0016323902) (0.00010558612, 0.0016325806) (0.00010565224, 0.0016327654) (0.00010573616, 0.0016329428) (0.00010583706, 0.0016331111) (0.00010595398, 0.0016332688) (0.00010608579, 0.0016334142) (0.00010623121, 0.001633546) (0.00010638886, 0.0016336629) (0.00010655721, 0.0016337638) (0.00010673463, 0.0016338478) (0.00010691943, 0.0016339139) (0.00010710982, 0.0016339616) (0.00010730397, 0.0016339904) (0.0001075, 0.001634) (0.0001185, 0.001634) (0.00011869603, 0.0016339904) (0.00011889018, 0.0016339616) (0.00011908057, 0.0016339139) (0.00011926537, 0.0016338478) (0.00011944279, 0.0016337638) (0.00011961114, 0.0016336629) (0.00011976879, 0.001633546) (0.00011991421, 0.0016334142) (0.00012004602, 0.0016332688) (0.00012016294, 0.0016331111) (0.00012026384, 0.0016329428) (0.00012034776, 0.0016327654) (0.00012041388, 0.0016325806) (0.00012046157, 0.0016323902) (0.00012049037, 0.001632196) (0.0001205, 0.001632) (0.0001205, 0.001598) (0.00012049037, 0.001597804) (0.00012046157, 0.0015976098) (0.00012041388, 0.0015974194) (0.00012034776, 0.0015972346) (0.00012026384, 0.0015970572) (0.00012016294, 0.0015968889) (0.00012004602, 0.0015967312) (0.00011991421, 0.0015965858) (0.00011976879, 0.001596454) (0.00011961114, 0.0015963371) (0.00011944279, 0.0015962362) (0.00011926537, 0.0015961522) (0.00011908057, 0.0015960861) (0.00011889018, 0.0015960384) (0.00011869603, 0.0015960096) (0.0001185, 0.001596) (0.0001075, 0.001596), closed, covered)
  head_b_cj = polyline(z=0, xy: (0.0001315, 0.001596) (0.00013130397, 0.0015960096) (0.00013110982, 0.0015960384) (0.00013091943, 0.0015960861) (0.00013073463, 0.0015961522) (0.00013055721, 0.0015962362) (0.00013038886, 0.0015963371) (0.00013023121, 0.001596454) (0.00013008579, 0.0015965858) (0.00012995398, 0.0015967312) (0.00012983706, 0.0015968889) (0.00012973616, 0.0015970572) (0.00012965224, 0.0015972346) (0.00012958612, 0.0015974194) (0.00012953843, 0.0015976098) (0.00012950963, 0.001597804) (0.0001295, 0.001598) (0.0001295, 0.001632) (0.00012950963, 0.001632196) (0.00012953843, 0.0016323902) (0.00012958612, 0.0016325806) (0.00012965224, 0.0016327654) (0.00012973616, 0.0016329428) (0.00012983706, 0.0016331111) (0.00012995398, 0.0016332688) (0.00013008579, 0.0016334142) (0.00013023121, 0.001633546) (0.00013038886, 0.0016336629) (0.00013055721, 0.0016337638) (0.00013073463, 0.0016338478) (0.00013091943, 0.0016339139) (0.00013110982, 0.0016339616) (0.00013130397, 0.0016339904) (0.0001315, 0.001634) (0.0001425, 0.001634) (0.00014269603, 0.0016339904) (0.00014289018, 0.0016339616) (0.00014308057, 0.0016339139) (0.00014326537, 0.0016338478) (0.00014344279, 0.0016337638) (0.00014361114, 0.0016336629) (0.00014376879, 0.001633546) (0.00014391421, 0.0016334142) (0.00014404602, 0.0016332688) (0.00014416294, 0.0016331111) (0.00014426384, 0.0016329428) (0.00014434776, 0.0016327654) (0.00014441388, 0.0016325806) (0.00014446157, 0.0016323902) (0.00014449037, 0.001632196) (0.0001445, 0.001632) (0.0001445, 0.001598) (0.00014449037, 0.001597804) (0.00014446157, 0.0015976098) (0.00014441388, 0.0015974194) (0.00014434776, 0.0015972346) (0.00014426384, 0.0015970572) (0.00014416294, 0.0015968889) (0.00014404602, 0.0015967312) (0.00014391421, 0.0015965858) (0.00014376879, 0.001596454) (0.00014361114, 0.0015963371) (0.00014344279, 0.0015962362) (0.00014326537, 0.0015961522) (0.00014308057, 0.0015960861) (0.00014289018, 0.0015960384) (0.00014269603, 0.0015960096) (0.0001425, 0.001596) (0.0001315, 0.001596), closed, covered)
  pocket_cj = polyline(z=0, xy: (9.75e-05, 0.001586) (9.7303966e-05, 0.0015860096) (9.7109819e-05, 0.0015860384) (9.6919431e-05, 0.0015860861) (9.6734633e-05, 0.0015861522) (9.6557207e-05, 0.0015862362) (9.638886e-05, 0.0015863371) (9.6231213e-05, 0.001586454) (9.6085786e-05, 0.0015865858) (9.5953979e-05, 0.0015867312) (9.5837061e-05, 0.0015868889) (9.5736157e-05, 0.0015870572) (9.5652241e-05, 0.0015872346) (9.5586119e-05, 0.0015874194) (9.5538429e-05, 0.0015876098) (9.5509631e-05, 0.001587804) (9.55e-05, 0.001588) (9.55e-05, 0.001642) (9.5509631e-05, 0.001642196) (9.5538429e-05, 0.0016423902) (9.5586119e-05, 0.0016425806) (9.5652241e-05, 0.0016427654) (9.5736157e-05, 0.0016429428) (9.5837061e-05, 0.0016431111) (9.5953979e-05, 0.0016432688) (9.6085786e-05, 0.0016434142) (9.6231213e-05, 0.001643546) (9.638886e-05, 0.0016436629) (9.6557207e-05, 0.0016437638) (9.6734633e-05, 0.0016438478) (9.6919431e-05, 0.0016439139) (9.7109819e-05, 0.0016439616) (9.7303966e-05, 0.0016439904) (9.75e-05, 0.001644) (0.0001525, 0.001644) (0.00015269603, 0.0016439904) (0.00015289018, 0.0016439616) (0.00015308057, 0.0016439139) (0.00015326537, 0.0016438478) (0.00015344279, 0.0016437638) (0.00015361114, 0.0016436629) (0.00015376879, 0.001643546) (0.00015391421, 0.0016434142) (0.00015404602, 0.0016432688) (0.00015416294, 0.0016431111) (0.00015426384, 0.0016429428) (0.00015434776, 0.0016427654) (0.00015441388, 0.0016425806) (0.00015446157, 0.0016423902) (0.00015449037, 0.001642196) (0.0001545, 0.001642) (0.0001545, 0.001588) (0.00015449037, 0.001587804) (0.00015446157, 0.0015876098) (0.00015441388, 0.0015874194) (0.00015434776, 0.0015872346) (0.00015426384, 0.0015870572) (0.00015416294, 0.0015868889) (0.00015404602, 0.0015867312) (0.00015391421, 0.0015865858) (0.00015376879, 0.001586454) (0.00015361114, 0.0015863371) (0.00015344279, 0.0015862362) (0.00015326537, 0.0015861522) (0.00015308057, 0.0015860861) (0.00015289018, 0.0015860384) (0.00015269603, 0.0015860096) (0.0001525, 0.001586) (9.75e-05, 0.001586), closed, covered)
  open_to_ground_readout_open = rectangle(corner=(0.000239, 0.002915, 0), x_size=2.2e-05, y_size=6e-06)
  endcap_feed_in_start = rectangle(corner=(-0.001626, -1.1e-05, 0), x_size=6e-06, y_size=2.2e-05)
  endcap_feed_out_end = rectangle(corner=(0.00162, -1.1e-05, 0), x_size=6e-06, y_size=2.2e-05)
  ground_main_plane = rectangle(corner=(-0.00182, -0.000347, 0), x_size=0.00364, y_size=0.003468)
  main [silicon_eps11p45] = box(corner=(-0.00182, -0.000347, -0.0005), size=(0.00364, 0.003468, 0.0005))
  sample_holder [vacuum] = box(corner=(-0.00182, -0.000347, -0.00165), size=(0.00364, 0.003468, 0.00254))
  ground_main_plane.subtract(pocket_cp, tap_cut_jr, pocket_cj, tap_cut_n0, cut_stub_p, open_to_ground_readout_open, cut_stub_r, endcap_feed_in_start, lead_a_sub_cp, lead_b_sub_cj, cut_filter_tail, endcap_feed_out_end, cut_stub_f, pocket_cin, cut_feed_in, lead_b_sub_cin, lead_b_sub_cp, cut_feed_mid, lead_a_sub_cj, lead_a_sub_cin, cut_res_tail, tap_cut_jf, cut_feed_out, cut_res_open_run, cut_feed_jf)
  Port_feed_in_start = rectangle(corner=(-0.001626, -5e-06, 0), x_size=6e-06, y_size=1e-05)
  voltage_line_Port_feed_in_start = polyline((-0.00162, 0, 0) (-0.001626, 0, 0))
  Port_feed_out_end = rectangle(corner=(0.00162, -5e-06, 0), x_size=6e-06, y_size=1e-05)
  voltage_line_Port_feed_out_end = polyline((0.00162, 0, 0) (0.001626, 0, 0))
  g_wb_13 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=5.325e-05 YPadPos=0.001585 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_14 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00019675 YPadPos=0.001585 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
boundaries and excitations:
  RLCBoundary_feed_in_start: Lumped RLC Objects=Port_feed_in_start CurrentLine{middle of Port_feed_in_start.edge(x at corner) -> middle of Port_feed_in_start.edge(x opposite corner)} RLC_Type=Parallel Resistance=50ohm
  RLCBoundary_feed_out_end: Lumped RLC Objects=Port_feed_out_end CurrentLine{middle of Port_feed_out_end.edge(x at corner) -> middle of Port_feed_out_end.edge(x opposite corner)} RLC_Type=Parallel Resistance=50ohm
  PerfE: Perfect E Objects=[lead_a_cin, lead_b_cin, lead_a_cp, lead_b_cp, trace_feed_in, trace_feed_mid, trace_feed_out, trace_stub_p, lead_a_cj, lead_b_cj, trace_stub_f, trace_stub_r, trace_feed_jf, trace_res_open_run, trace_filter_tail, trace_res_tail, plate_cin, frame_cin, tap_trace_n0, plate_cp, frame_cp, tap_trace_jf, tap_trace_jr, head_a_cj, head_b_cj, ground_main_plane]
mesh:
  port_mesh: LengthBased Objects=[Port_feed_in_start, Port_feed_out_end] MaxLength=7um
  cpw_line_mesh: LengthBased Objects=[lead_a_cin, lead_b_cin, trace_feed_in, trace_feed_mid, trace_feed_out, trace_stub_p, trace_stub_f, trace_stub_r, trace_feed_jf, trace_res_open_run, trace_filter_tail, trace_res_tail, plate_cin, frame_cin, tap_trace_n0, tap_trace_jf, tap_trace_jr] MaxLength=20um
  cap_mesh: LengthBased Objects=[lead_a_cp, lead_b_cp, lead_a_cj, lead_b_cj, plate_cp, frame_cp, head_a_cj, head_b_cj] MaxLength=9um
setups:
  Setup: HfssEigen MinimumFrequency=5.95GHz NumModes=2 MaxDeltaFreq=0.1 ConvergeOnRealFreq=true MaximumPasses=15 MinimumPasses=3 MinimumConvergedPasses=2 PercentRefinement=20 BasisOrder=1
source amplitudes:
  #-10:1: 1 0deg
  #-10:2: 0 0deg
reports:
  Eigen Modes Plot 1: re(Mode(1)), re(Mode(2)) vs Pass on Setup : AdaptivePass

design P250g9_cpwwb_m9um_2014_hfss (HFSS, Eigenmode, model units mm)
geometry:
  lead_a_cin_path = polyline((-0.000740499, 0, 0) (-0.0007925, 0, 0))
  lead_a_cin = polyline((-0.000740499, -5e-06, 0) (-0.000740499, 5e-06, 0))
  lead_a_cin.sweep_along_path(lead_a_cin_path)
  lead_a_sub_cin_path = polyline((-0.000740499, 0, 0) (-0.0007925, 0, 0))
  lead_a_sub_cin = polyline((-0.000740499, -1.1e-05, 0) (-0.000740499, 1.1e-05, 0))
  lead_a_sub_cin.sweep_along_path(lead_a_sub_cin_path)
  lead_b_cin_path = polyline((-0.000639501, 0, 0) (-0.0005275, 0, 0))
  lead_b_cin = polyline((-0.000639501, 5e-06, 0) (-0.000639501, -5e-06, 0))
  lead_b_cin.sweep_along_path(lead_b_cin_path)
  lead_b_sub_cin_path = polyline((-0.000639501, 0, 0) (-0.0005275, 0, 0))
  lead_b_sub_cin = polyline((-0.000639501, 1.1e-05, 0) (-0.000639501, -1.1e-05, 0))
  lead_b_sub_cin.sweep_along_path(lead_b_sub_cin_path)
  lead_a_cp_path = polyline((0, 0.000202001, 0) (0, 0.00015, 0))
  lead_a_cp = polyline((5e-06, 0.000202001, 0) (-5e-06, 0.000202001, 0))
  lead_a_cp.sweep_along_path(lead_a_cp_path)
  lead_a_sub_cp_path = polyline((0, 0.000202001, 0) (0, 0.00015, 0))
  lead_a_sub_cp = polyline((1.1e-05, 0.000202001, 0) (-1.1e-05, 0.000202001, 0))
  lead_a_sub_cp.sweep_along_path(lead_a_sub_cp_path)
  lead_b_cp_path = polyline((0, 0.000302999, 0) (0, 0.000415, 0))
  lead_b_cp = polyline((-5e-06, 0.000302999, 0) (5e-06, 0.000302999, 0))
  lead_b_cp.sweep_along_path(lead_b_cp_path)
  lead_b_sub_cp_path = polyline((0, 0.000302999, 0) (0, 0.000415, 0))
  lead_b_sub_cp = polyline((-1.1e-05, 0.000302999, 0) (1.1e-05, 0.000302999, 0))
  lead_b_sub_cp.sweep_along_path(lead_b_sub_cp_path)
  trace_feed_in_path = polyline((-0.00162, 0, 0) (-0.0007925, 0, 0))
  trace_feed_in = polyline((-0.00162, 5e-06, 0) (-0.00162, -5e-06, 0))
  trace_feed_in.sweep_along_path(trace_feed_in_path)
  cut_feed_in_path = polyline((-0.00162, 0, 0) (-0.0007925, 0, 0))
  cut_feed_in = polyline((-0.00162, 1.1e-05, 0) (-0.00162, -1.1e-05, 0))
  cut_feed_in.sweep_along_path(cut_feed_in_path)
  trace_feed_mid_path = polyline((-0.0005275, 0, 0) (-0.00015, 0, 0))
  trace_feed_mid = polyline((-0.0005275, 5e-06, 0) (-0.0005275, -5e-06, 0))
  trace_feed_mid.sweep_along_path(trace_feed_mid_path)
  cut_feed_mid_path = polyline((-0.0005275, 0, 0) (-0.00015, 0, 0))
  cut_feed_mid = polyline((-0.0005275, 1.1e-05, 0) (-0.0005275, -1.1e-05, 0))
  cut_feed_mid.sweep_along_path(cut_feed_mid_path)
  trace_feed_out_path = polyline((0.00015, 0, 0) (0.00162, 0, 0))
  trace_feed_out = polyline((0.00015, 5e-06, 0) (0.00015, -5e-06, 0))
  trace_feed_out.sweep_along_path(trace_feed_out_path)
  cut_feed_out_path = polyline((0.00015, 0, 0) (0.00162, 0, 0))
  cut_feed_out = polyline((0.00015, 1.1e-05, 0) (0.00015, -1.1e-05, 0))
  cut_feed_out.sweep_along_path(cut_feed_out_path)
  trace_stub_p_path = polyline((0, 0.0001, 0) (0, 0.00015, 0))
  trace_stub_p = polyline((-5e-06, 0.0001, 0) (5e-06, 0.0001, 0))
  trace_stub_p.sweep_along_path(trace_stub_p_path)
  cut_stub_p_path = polyline((0, 0.0001, 0) (0, 0.00015, 0))
  cut_stub_p = polyline((-1.1e-05, 0.0001, 0) (1.1e-05, 0.0001, 0))
  cut_stub_p.sweep_along_path(cut_stub_p_path)
  lead_a_cj_path = polyline((0.000105501, 0.001615, 0) (9.55e-05, 0.001615, 0))
  lead_a_cj = polyline((0.000105501, 0.00161, 0) (0.000105501, 0.00162, 0))
  lead_a_cj.sweep_along_path(lead_a_cj_path)
  lead_a_sub_cj_path = polyline((0.000105501, 0.001615, 0) (9.55e-05, 0.001615, 0))
  lead_a_sub_cj = polyline((0.000105501, 0.001604, 0) (0.000105501, 0.001626, 0))
  lead_a_sub_cj.sweep_along_path(lead_a_sub_cj_path)
  lead_b_cj_path = polyline((0.000144499, 0.001615, 0) (0.0001545, 0.001615, 0))
  lead_b_cj = polyline((0.000144499, 0.00162, 0) (0.000144499, 0.00161, 0))
  lead_b_cj.sweep_along_path(lead_b_cj_path)
  lead_b_sub_cj_path = polyline((0.000144499, 0.001615, 0) (0.0001545, 0.001615, 0))
  lead_b_sub_cj = polyline((0.000144499, 0.001626, 0) (0.000144499, 0.001604, 0))
  lead_b_sub_cj.sweep_along_path(lead_b_sub_cj_path)
  trace_stub_f_path = polyline((7.55e-05, 0.001615, 0) (9.55e-05, 0.001615, 0))
  trace_stub_f = polyline((7.55e-05, 0.00162, 0) (7.55e-05, 0.00161, 0))
  trace_stub_f.sweep_along_path(trace_stub_f_path)
  cut_stub_f_path = polyline((7.55e-05, 0.001615, 0) (9.55e-05, 0.001615, 0))
  cut_stub_f = polyline((7.55e-05, 0.001626, 0) (7.55e-05, 0.001604, 0))
  cut_stub_f.sweep_along_path(cut_stub_f_path)
  trace_stub_r_path = polyline((0.0001545, 0.001615, 0) (0.0001745, 0.001615, 0))
  trace_stub_r = polyline((0.0001545, 0.00162, 0) (0.0001545, 0.00161, 0))
  trace_stub_r.sweep_along_path(trace_stub_r_path)
  cut_stub_r_path = polyline((0.0001545, 0.001615, 0) (0.0001745, 0.001615, 0))
  cut_stub_r = polyline((0.0001545, 0.001626, 0) (0.0001545, 0.001604, 0))
  cut_stub_r.sweep_along_path(cut_stub_r_path)
  trace_feed_jf_path = polyline((0, 0.000415, 0) (0, 0.001465, 0))
  trace_feed_jf = polyline((-5e-06, 0.000415, 0) (5e-06, 0.000415, 0))
  trace_feed_jf.sweep_along_path(trace_feed_jf_path)
  cut_feed_jf_path = polyline((0, 0.000415, 0) (0, 0.001465, 0))
  cut_feed_jf = polyline((-1.1e-05, 0.000415, 0) (1.1e-05, 0.000415, 0))
  cut_feed_jf.sweep_along_path(cut_feed_jf_path)
  trace_res_open_run_path = polyline((0.00025, 0.001765, 0) (0.00025, 0.002915, 0))
  trace_res_open_run = polyline((0.000245, 0.001765, 0) (0.000255, 0.001765, 0))
  trace_res_open_run.sweep_along_path(trace_res_open_run_path)
  cut_res_open_run_path = polyline((0.00025, 0.001765, 0) (0.00025, 0.002915, 0))
  cut_res_open_run = polyline((0.000239, 0.001765, 0) (0.000261, 0.001765, 0))
  cut_res_open_run.sweep_along_path(cut_res_open_run_path)
  trace_filter_tail_path = polyline(z=0, xy: (0, 0.001765) (0, 0.002285) (-0.00051923387, 0.002285) (-0.00051923387, 0.002055) (-0.00025, 0.002055) (-0.00025, 0.001825) (-0.00051923387, 0.001825) (-0.00051923387, 0.001595) (-0.00025, 0.001595) (-0.00025, 0.001365) (-0.00051923387, 0.001365) (-0.00051923387, 0.001135))
  trace_filter_tail_path.fillet(Vertices=trace_filter_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  trace_filter_tail = polyline((-5e-06, 0.001765, 0) (5e-06, 0.001765, 0))
  trace_filter_tail.sweep_along_path(trace_filter_tail_path)
  cut_filter_tail_path = polyline(z=0, xy: (0, 0.001765) (0, 0.002285) (-0.00051923387, 0.002285) (-0.00051923387, 0.002055) (-0.00025, 0.002055) (-0.00025, 0.001825) (-0.00051923387, 0.001825) (-0.00051923387, 0.001595) (-0.00025, 0.001595) (-0.00025, 0.001365) (-0.00051923387, 0.001365) (-0.00051923387, 0.001135))
  cut_filter_tail_path.fillet(Vertices=cut_filter_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  cut_filter_tail = polyline((-1.1e-05, 0.001765, 0) (1.1e-05, 0.001765, 0))
  cut_filter_tail.sweep_along_path(cut_filter_tail_path)
  trace_res_tail_path = polyline(z=0, xy: (0.00025, 0.001465) (0.00025, 0.000765) (0.00077617693, 0.000765) (0.00077617693, 0.000995) (0.0005, 0.000995) (0.0005, 0.001225) (0.00077617693, 0.001225) (0.00077617693, 0.001455) (0.0005, 0.001455) (0.0005, 0.001685) (0.00077617693, 0.001685) (0.00077617693, 0.001906))
  trace_res_tail_path.fillet(Vertices=trace_res_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  trace_res_tail = polyline((0.000255, 0.001465, 0) (0.000245, 0.001465, 0))
  trace_res_tail.sweep_along_path(trace_res_tail_path)
  cut_res_tail_path = polyline(z=0, xy: (0.00025, 0.001465) (0.00025, 0.000765) (0.00077617693, 0.000765) (0.00077617693, 0.000995) (0.0005, 0.000995) (0.0005, 0.001225) (0.00077617693, 0.001225) (0.00077617693, 0.001455) (0.0005, 0.001455) (0.0005, 0.001685) (0.00077617693, 0.001685) (0.00077617693, 0.001906))
  cut_res_tail_path.fillet(Vertices=cut_res_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  cut_res_tail = polyline((0.000261, 0.001465, 0) (0.000239, 0.001465, 0))
  cut_res_tail.sweep_along_path(cut_res_tail_path)
  plate_cin = polyline(z=0, xy: (-0.0006725, -7e-05) (-0.00067328414, -6.9961478e-05) (-0.00067406072, -6.9846282e-05) (-0.00067482228, -6.9655523e-05) (-0.00067556147, -6.9391036e-05) (-0.00067627117, -6.905537e-05) (-0.00067694456, -6.8651757e-05) (-0.00067757515, -6.8184084e-05) (-0.00067815685, -6.7656854e-05) (-0.00067868408, -6.7075146e-05) (-0.00067915176, -6.6444562e-05) (-0.00067955537, -6.5771174e-05) (-0.00067989104, -6.5061467e-05) (-0.00068015552, -6.4322277e-05) (-0.00068034628, -6.3560723e-05) (-0.00068046148, -6.2784137e-05) (-0.0006805, -6.2e-05) (-0.0006805, 6.2e-05) (-0.00068046148, 6.2784137e-05) (-0.00068034628, 6.3560723e-05) (-0.00068015552, 6.4322277e-05) (-0.00067989104, 6.5061467e-05) (-0.00067955537, 6.5771174e-05) (-0.00067915176, 6.6444562e-05) (-0.00067868408, 6.7075146e-05) (-0.00067815685, 6.7656854e-05) (-0.00067757515, 6.8184084e-05) (-0.00067694456, 6.8651757e-05) (-0.00067627117, 6.905537e-05) (-0.00067556147, 6.9391036e-05) (-0.00067482228, 6.9655523e-05) (-0.00067406072, 6.9846282e-05) (-0.00067328414, 6.9961478e-05) (-0.0006725, 7e-05) (-0.0006475, 7e-05) (-0.00064671586, 6.9961478e-05) (-0.00064593928, 6.9846282e-05) (-0.00064517772, 6.9655523e-05) (-0.00064443853, 6.9391036e-05) (-0.00064372883, 6.905537e-05) (-0.00064305544, 6.8651757e-05) (-0.00064242485, 6.8184084e-05) (-0.00064184315, 6.7656854e-05) (-0.00064131592, 6.7075146e-05) (-0.00064084824, 6.6444562e-05) (-0.00064044463, 6.5771174e-05) (-0.00064010896, 6.5061467e-05) (-0.00063984448, 6.4322277e-05) (-0.00063965372, 6.3560723e-05) (-0.00063953852, 6.2784137e-05) (-0.0006395, 6.2e-05) (-0.0006395, -6.2e-05) (-0.00063953852, -6.2784137e-05) (-0.00063965372, -6.3560723e-05) (-0.00063984448, -6.4322277e-05) (-0.00064010896, -6.5061467e-05) (-0.00064044463, -6.5771174e-05) (-0.00064084824, -6.6444562e-05) (-0.00064131592, -6.7075146e-05) (-0.00064184315, -6.7656854e-05) (-0.00064242485, -6.8184084e-05) (-0.00064305544, -6.8651757e-05) (-0.00064372883, -6.905537e-05) (-0.00064443853, -6.9391036e-05) (-0.00064517772, -6.9655523e-05) (-0.00064593928, -6.9846282e-05) (-0.00064671586, -6.9961478e-05) (-0.0006475, -7e-05) (-0.0006725, -7e-05), closed, covered)
  frame_cin = polyline(z=0, xy: (-0.0006885, -7e-05) (-0.00068846148, -7.0784137e-05) (-0.00068834628, -7.1560723e-05) (-0.00068815552, -7.2322277e-05) (-0.00068789104, -7.3061467e-05) (-0.00068755537, -7.3771174e-05) (-0.00068715176, -7.4444562e-05) (-0.00068668408, -7.5075146e-05) (-0.00068615685, -7.5656854e-05) (-0.00068557515, -7.6184084e-05) (-0.00068494456, -7.6651757e-05) (-0.00068427117, -7.705537e-05) (-0.00068356147, -7.7391036e-05) (-0.00068282228, -7.7655523e-05) (-0.00068206072, -7.7846282e-05) (-0.00068128414, -7.7961478e-05) (-0.0006805, -7.8e-05) (-0.0006395, -7.8e-05) (-0.00063871586, -7.7961478e-05) (-0.00063793928, -7.7846282e-05) (-0.00063717772, -7.7655523e-05) (-0.00063643853, -7.7391036e-05) (-0.00063572883, -7.705537e-05) (-0.00063505544, -7.6651757e-05) (-0.00063442485, -7.6184084e-05) (-0.00063384315, -7.5656854e-05) (-0.00063331592, -7.5075146e-05) (-0.00063284824, -7.4444562e-05) (-0.00063244463, -7.3771174e-05) (-0.00063210896, -7.3061467e-05) (-0.00063184448, -7.2322277e-05) (-0.00063165372, -7.1560723e-05) (-0.00063153852, -7.0784137e-05) (-0.0006315, -7e-05) (-0.0006315, -1.909818e-05) (-0.00063149518, -1.8901939e-05) (-0.00063147111, -1.8412015e-05) (-0.00063143266, -1.80216e-05) (-0.0006313751, -1.7633541e-05) (-0.00063129856, -1.7248774e-05) (-0.00063120324, -1.6868226e-05) (-0.00063108936, -1.6492814e-05) (-0.0006309572, -1.6123441e-05) (-0.00063080707, -1.5760999e-05) (-0.00063063934, -1.540636e-05) (-0.00063045441, -1.5060378e-05) (-0.00063025272, -1.4723887e-05) (-0.00063003477, -1.4397697e-05) (-0.00062980107, -1.4082595e-05) (-0.0006295522, -1.3779339e-05) (-0.00062928874, -1.348866e-05) (-0.00062901134, -1.3211259e-05) (-0.00062872066, -1.2947803e-05) (-0.00062841741, -1.2698928e-05) (-0.0006281023, -1.2465232e-05) (-0.00062777611, -1.2247279e-05) (-0.00062743962, -1.2045594e-05) (-0.00062709364, -1.1860663e-05) (-0.000626739, -1.1692931e-05) (-0.00062637656, -1.1542802e-05) (-0.00062600719, -1.1410639e-05) (-0.00062563177, -1.1296759e-05) (-0.00062525123, -1.1201436e-05) (-0.00062486646, -1.1124902e-05) (-0.0006244784, -1.1067338e-05) (-0.00062408799, -1.1028886e-05) (-0.00062359806, -1.1004817e-05) (-0.00062340182, -1.1e-05) (-0.00057559818, -1.1e-05) (-0.00057540194, -1.1004817e-05) (-0.00057491201, -1.1028886e-05) (-0.0005745216, -1.1067338e-05) (-0.00057413354, -1.1124902e-05) (-0.00057374877, -1.1201436e-05) (-0.00057336823, -1.1296759e-05) (-0.00057299281, -1.1410639e-05) (-0.00057262344, -1.1542802e-05) (-0.000572261, -1.1692931e-05) (-0.00057190636, -1.1860663e-05) (-0.00057156038, -1.2045594e-05) (-0.00057122389, -1.2247279e-05) (-0.0005708977, -1.2465232e-05) (-0.0005705826, -1.2698928e-05) (-0.00057027934, -1.2947803e-05) (-0.00056998866, -1.3211259e-05) (-0.00056971126, -1.348866e-05) (-0.0005694478, -1.3779339e-05) (-0.00056919893, -1.4082595e-05) (-0.00056896523, -1.4397697e-05) (-0.00056874728, -1.4723887e-05) (-0.00056854559, -1.5060378e-05) (-0.00056836066, -1.540636e-05) (-0.00056819293, -1.5760999e-05) (-0.0005680428, -1.6123441e-05) (-0.00056791064, -1.6492814e-05) (-0.00056779676, -1.6868226e-05) (-0.00056770144, -1.7248774e-05) (-0.0005676249, -1.7633541e-05) (-0.00056756734, -1.80216e-05) (-0.00056752889, -1.8412015e-05) (-0.00056750482, -1.8901939e-05) (-0.0005675, -1.909818e-05) (-0.0005675, -0.00012690182) (-0.00056750482, -0.00012709806) (-0.00056752889, -0.00012758798) (-0.00056756734, -0.0001279784) (-0.0005676249, -0.00012836646) (-0.00056770144, -0.00012875123) (-0.00056779676, -0.00012913177) (-0.00056791064, -0.00012950719) (-0.0005680428, -0.00012987656) (-0.00056819293, -0.000130239) (-0.00056836066, -0.00013059364) (-0.00056854559, -0.00013093962) (-0.00056874728, -0.00013127611) (-0.00056896523, -0.0001316023) (-0.00056919893, -0.00013191741) (-0.0005694478, -0.00013222066) (-0.00056971126, -0.00013251134) (-0.00056998866, -0.00013278874) (-0.00057027934, -0.0001330522) (-0.0005705826, -0.00013330107) (-0.0005708977, -0.00013353477) (-0.00057122389, -0.00013375272) (-0.00057156038, -0.00013395441) (-0.00057190636, -0.00013413934) (-0.000572261, -0.00013430707) (-0.00057262344, -0.0001344572) (-0.00057299281, -0.00013458936) (-0.00057336823, -0.00013470324) (-0.00057374877, -0.00013479856) (-0.00057413354, -0.0001348751) (-0.0005745216, -0.00013493266) (-0.00057491201, -0.00013497111) (-0.00057540194, -0.00013499518) (-0.00057559818, -0.000135) (-0.00073240182, -0.000135) (-0.00073259806, -0.00013499518) (-0.00073308798, -0.00013497111) (-0.0007334784, -0.00013493266) (-0.00073386646, -0.0001348751) (-0.00073425123, -0.00013479856) (-0.00073463177, -0.00013470324) (-0.00073500719, -0.00013458936) (-0.00073537656, -0.0001344572) (-0.000735739, -0.00013430707) (-0.00073609364, -0.00013413934) (-0.00073643962, -0.00013395441) (-0.00073677611, -0.00013375272) (-0.0007371023, -0.00013353477) (-0.0007374174, -0.00013330107) (-0.00073772066, -0.0001330522) (-0.00073801134, -0.00013278874) (-0.00073828874, -0.00013251134) (-0.0007385522, -0.00013222066) (-0.00073880107, -0.00013191741) (-0.00073903477, -0.0001316023) (-0.00073925272, -0.00013127611) (-0.00073945441, -0.00013093962) (-0.00073963934, -0.00013059364) (-0.00073980707, -0.000130239) (-0.0007399572, -0.00012987656) (-0.00074008936, -0.00012950719) (-0.00074020324, -0.00012913177) (-0.00074029856, -0.00012875123) (-0.0007403751, -0.00012836646) (-0.00074043266, -0.0001279784) (-0.00074047111, -0.00012758798) (-0.00074049518, -0.00012709806) (-0.0007405, -0.00012690182) (-0.0007405, 0.00012690182) (-0.00074049518, 0.00012709806) (-0.00074047111, 0.00012758798) (-0.00074043266, 0.0001279784) (-0.0007403751, 0.00012836646) (-0.00074029856, 0.00012875123) (-0.00074020324, 0.00012913177) (-0.00074008936, 0.00012950719) (-0.0007399572, 0.00012987656) (-0.00073980707, 0.000130239) (-0.00073963934, 0.00013059364) (-0.00073945441, 0.00013093962) (-0.00073925272, 0.00013127611) (-0.00073903477, 0.0001316023) (-0.00073880107, 0.00013191741) (-0.0007385522, 0.00013222066) (-0.00073828874, 0.00013251134) (-0.00073801134, 0.00013278874) (-0.00073772066, 0.0001330522) (-0.0007374174, 0.00013330107) (-0.0007371023, 0.00013353477) (-0.00073677611, 0.00013375272) (-0.00073643962, 0.00013395441) (-0.00073609364, 0.00013413934) (-0.000735739, 0.00013430707) (-0.00073537656, 0.0001344572) (-0.00073500719, 0.00013458936) (-0.00073463177, 0.00013470324) (-0.00073425123, 0.00013479856) (-0.00073386646, 0.0001348751) (-0.0007334784, 0.00013493266) (-0.00073308798, 0.00013497111) (-0.00073259806, 0.00013499518) (-0.00073240182, 0.000135) (-0.00057559818, 0.000135) (-0.00057540194, 0.00013499518) (-0.00057491201, 0.00013497111) (-0.0005745216, 0.00013493266) (-0.00057413354, 0.0001348751) (-0.00057374877, 0.00013479856) (-0.00057336823, 0.00013470324) (-0.00057299281, 0.00013458936) (-0.00057262344, 0.0001344572) (-0.000572261, 0.00013430707) (-0.00057190636, 0.00013413934) (-0.00057156038, 0.00013395441) (-0.00057122389, 0.00013375272) (-0.0005708977, 0.00013353477) (-0.0005705826, 0.00013330107) (-0.00057027934, 0.0001330522) (-0.00056998866, 0.00013278874) (-0.00056971126, 0.00013251134) (-0.0005694478, 0.00013222066) (-0.00056919893, 0.00013191741) (-0.00056896523, 0.0001316023) (-0.00056874728, 0.00013127611) (-0.00056854559, 0.00013093962) (-0.00056836066, 0.00013059364) (-0.00056819293, 0.000130239) (-0.0005680428, 0.00012987656) (-0.00056791064, 0.00012950719) (-0.00056779676, 0.00012913177) (-0.00056770144, 0.00012875123) (-0.0005676249, 0.00012836646) (-0.00056756734, 0.0001279784) (-0.00056752889, 0.00012758798) (-0.00056750482, 0.00012709806) (-0.0005675, 0.00012690182) (-0.0005675, 1.909818e-05) (-0.00056750482, 1.8901939e-05) (-0.00056752889, 1.8412015e-05) (-0.00056756734, 1.80216e-05) (-0.0005676249, 1.7633541e-05) (-0.00056770144, 1.7248774e-05) (-0.00056779676, 1.6868226e-05) (-0.00056791064, 1.6492814e-05) (-0.0005680428, 1.6123441e-05) (-0.00056819293, 1.5760999e-05) (-0.00056836066, 1.540636e-05) (-0.00056854559, 1.5060378e-05) (-0.00056874728, 1.4723887e-05) (-0.00056896523, 1.4397697e-05) (-0.00056919893, 1.4082595e-05) (-0.0005694478, 1.3779339e-05) (-0.00056971126, 1.348866e-05) (-0.00056998866, 1.3211259e-05) (-0.00057027934, 1.2947803e-05) (-0.0005705826, 1.2698928e-05) (-0.0005708977, 1.2465232e-05) (-0.00057122389, 1.2247279e-05) (-0.00057156038, 1.2045594e-05) (-0.00057190636, 1.1860663e-05) (-0.000572261, 1.1692931e-05) (-0.00057262344, 1.1542802e-05) (-0.00057299281, 1.1410639e-05) (-0.00057336823, 1.1296759e-05) (-0.00057374877, 1.1201436e-05) (-0.00057413354, 1.1124902e-05) (-0.0005745216, 1.1067338e-05) (-0.00057491201, 1.1028886e-05) (-0.00057540194, 1.1004817e-05) (-0.00057559818, 1.1e-05) (-0.00062340182, 1.1e-05) (-0.00062359806, 1.1004817e-05) (-0.00062408799, 1.1028886e-05) (-0.0006244784, 1.1067338e-05) (-0.00062486646, 1.1124902e-05) (-0.00062525123, 1.1201436e-05) (-0.00062563177, 1.1296759e-05) (-0.00062600719, 1.1410639e-05) (-0.00062637656, 1.1542802e-05) (-0.000626739, 1.1692931e-05) (-0.00062709364, 1.1860663e-05) (-0.00062743962, 1.2045594e-05) (-0.00062777611, 1.2247279e-05) (-0.0006281023, 1.2465232e-05) (-0.00062841741, 1.2698928e-05) (-0.00062872066, 1.2947803e-05) (-0.00062901134, 1.3211259e-05) (-0.00062928874, 1.348866e-05) (-0.0006295522, 1.3779339e-05) (-0.00062980107, 1.4082595e-05) (-0.00063003477, 1.4397697e-05) (-0.00063025272, 1.4723887e-05) (-0.00063045441, 1.5060378e-05) (-0.00063063934, 1.540636e-05) (-0.00063080707, 1.5760999e-05) (-0.0006309572, 1.6123441e-05) (-0.00063108936, 1.6492814e-05) (-0.00063120324, 1.6868226e-05)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, closed, covered)
  pocket_cin = polyline(z=0, xy: (-0.0007525, -0.000135) (-0.0007525, 0.000135) (-0.00075244222, 0.00013617621) (-0.00075226942, 0.00013734108) (-0.00075198328, 0.00013848342) (-0.00075158655, 0.0001395922) (-0.00075108306, 0.00014065676) (-0.00075047764, 0.00014166684) (-0.00074977613, 0.00014261272) (-0.00074898528, 0.00014348528) (-0.00074811272, 0.00014427613) (-0.00074716684, 0.00014497764) (-0.00074615676, 0.00014558305) (-0.0007450922, 0.00014608655) (-0.00074398342, 0.00014648328) (-0.00074284108, 0.00014676942) (-0.00074167621, 0.00014694222) (-0.0007405, 0.000147) (-0.0005675, 0.000147) (-0.00056632379, 0.00014694222) (-0.00056515892, 0.00014676942) (-0.00056401658, 0.00014648328) (-0.0005629078, 0.00014608655) (-0.00056184324, 0.00014558305) (-0.00056083316, 0.00014497764) (-0.00055988728, 0.00014427613) (-0.00055901472, 0.00014348528) (-0.00055822388, 0.00014261272) (-0.00055752237, 0.00014166684) (-0.00055691694, 0.00014065676) (-0.00055641345, 0.0001395922) (-0.00055601672, 0.00013848342) (-0.00055573058, 0.00013734108) (-0.00055555778, 0.00013617621) (-0.0005555, 0.000135) (-0.0005555, -0.000135) (-0.00055555778, -0.00013617621) (-0.00055573058, -0.00013734108) (-0.00055601672, -0.00013848342) (-0.00055641345, -0.0001395922) (-0.00055691694, -0.00014065676) (-0.00055752237, -0.00014166684) (-0.00055822388, -0.00014261272) (-0.00055901472, -0.00014348528) (-0.00055988728, -0.00014427613) (-0.00056083316, -0.00014497764) (-0.00056184324, -0.00014558305) (-0.0005629078, -0.00014608655) (-0.00056401658, -0.00014648328) (-0.00056515892, -0.00014676942) (-0.00056632379, -0.00014694222) (-0.0005675, -0.000147) (-0.0007405, -0.000147) (-0.00074167621, -0.00014694222) (-0.00074284108, -0.00014676942) (-0.00074398342, -0.00014648328) (-0.0007450922, -0.00014608655) (-0.00074615676, -0.00014558305) (-0.00074716684, -0.00014497764) (-0.00074811272, -0.00014427613) (-0.00074898528, -0.00014348528) (-0.00074977613, -0.00014261272) (-0.00075047764, -0.00014166684) (-0.00075108306, -0.00014065676) (-0.00075158655, -0.0001395922) (-0.00075198328, -0.00013848342) (-0.00075226942, -0.00013734108) (-0.00075244222, -0.00013617621) (-0.0007525, -0.000135), closed, covered)
  tap_trace_n0 = polyline(z=0, xy: (0.00015, -5e-06) (-0.00015, -5e-06) (-0.00015, 5e-06) (-5e-06, 5e-06) (-5e-06, 0.0001) (5e-06, 0.0001) (5e-06, 5e-06) (0.00015, 5e-06) (0.00015, -5e-06), closed, covered)
  tap_cut_n0 = polyline(z=0, xy: (0.00015, -1.1e-05) (-0.00015, -1.1e-05) (-0.00015, 1.1e-05) (-1.1e-05, 1.1e-05) (-1.1e-05, 0.0001) (1.1e-05, 0.0001) (1.1e-05, 1.1e-05) (0.00015, 1.1e-05) (0.00015, -1.1e-05), closed, covered)
  plate_cp = polyline(z=0, xy: (7e-05, 0.00027) (6.9961478e-05, 0.00026921586) (6.9846282e-05, 0.00026843928) (6.9655523e-05, 0.00026767772) (6.9391036e-05, 0.00026693853) (6.905537e-05, 0.00026622883) (6.8651757e-05, 0.00026555544) (6.8184084e-05, 0.00026492485) (6.7656854e-05, 0.00026434315) (6.7075146e-05, 0.00026381592) (6.6444562e-05, 0.00026334824) (6.5771174e-05, 0.00026294463) (6.5061467e-05, 0.00026260896) (6.4322277e-05, 0.00026234448) (6.3560723e-05, 0.00026215372) (6.2784137e-05, 0.00026203852) (6.2e-05, 0.000262) (-6.2e-05, 0.000262) (-6.2784137e-05, 0.00026203852) (-6.3560723e-05, 0.00026215372) (-6.4322277e-05, 0.00026234448) (-6.5061467e-05, 0.00026260896) (-6.5771174e-05, 0.00026294463) (-6.6444562e-05, 0.00026334824) (-6.7075146e-05, 0.00026381592) (-6.7656854e-05, 0.00026434315) (-6.8184084e-05, 0.00026492485) (-6.8651757e-05, 0.00026555544) (-6.905537e-05, 0.00026622883) (-6.9391036e-05, 0.00026693853) (-6.9655523e-05, 0.00026767772) (-6.9846282e-05, 0.00026843928) (-6.9961478e-05, 0.00026921586) (-7e-05, 0.00027) (-7e-05, 0.000295) (-6.9961478e-05, 0.00029578414) (-6.9846282e-05, 0.00029656072) (-6.9655523e-05, 0.00029732228) (-6.9391036e-05, 0.00029806147) (-6.905537e-05, 0.00029877117) (-6.8651757e-05, 0.00029944456) (-6.8184084e-05, 0.00030007515) (-6.7656854e-05, 0.00030065685) (-6.7075146e-05, 0.00030118408) (-6.6444562e-05, 0.00030165176) (-6.5771174e-05, 0.00030205537) (-6.5061467e-05, 0.00030239104) (-6.4322277e-05, 0.00030265552) (-6.3560723e-05, 0.00030284628) (-6.2784137e-05, 0.00030296148) (-6.2e-05, 0.000303) (6.2e-05, 0.000303) (6.2784137e-05, 0.00030296148) (6.3560723e-05, 0.00030284628) (6.4322277e-05, 0.00030265552) (6.5061467e-05, 0.00030239104) (6.5771174e-05, 0.00030205537) (6.6444562e-05, 0.00030165176) (6.7075146e-05, 0.00030118408) (6.7656854e-05, 0.00030065685) (6.8184084e-05, 0.00030007515) (6.8651757e-05, 0.00029944456) (6.905537e-05, 0.00029877117) (6.9391036e-05, 0.00029806147) (6.9655523e-05, 0.00029732228) (6.9846282e-05, 0.00029656072) (6.9961478e-05, 0.00029578414) (7e-05, 0.000295) (7e-05, 0.00027), closed, covered)
  frame_cp = polyline(z=0, xy: (7e-05, 0.000254) (7.0784137e-05, 0.00025403852) (7.1560723e-05, 0.00025415372) (7.2322277e-05, 0.00025434448) (7.3061467e-05, 0.00025460896) (7.3771174e-05, 0.00025494463) (7.4444562e-05, 0.00025534824) (7.5075146e-05, 0.00025581592) (7.5656854e-05, 0.00025634315) (7.6184084e-05, 0.00025692485) (7.6651757e-05, 0.00025755544) (7.705537e-05, 0.00025822883) (7.7391036e-05, 0.00025893853) (7.7655523e-05, 0.00025967772) (7.7846282e-05, 0.00026043928) (7.7961478e-05, 0.00026121586) (7.8e-05, 0.000262) (7.8e-05, 0.000303) (7.7961478e-05, 0.00030378414) (7.7846282e-05, 0.00030456072) (7.7655523e-05, 0.00030532228) (7.7391036e-05, 0.00030606147) (7.705537e-05, 0.00030677117) (7.6651757e-05, 0.00030744456) (7.6184084e-05, 0.00030807515) (7.5656854e-05, 0.00030865685) (7.5075146e-05, 0.00030918408) (7.4444562e-05, 0.00030965176) (7.3771174e-05, 0.00031005537) (7.3061467e-05, 0.00031039104) (7.2322277e-05, 0.00031065552) (7.1560723e-05, 0.00031084628) (7.0784137e-05, 0.00031096148) (7e-05, 0.000311) (1.909818e-05, 0.000311) (1.8901939e-05, 0.00031100482) (1.8412015e-05, 0.00031102889) (1.80216e-05, 0.00031106734) (1.7633541e-05, 0.0003111249) (1.7248774e-05, 0.00031120144) (1.6868226e-05, 0.00031129676) (1.6492814e-05, 0.00031141064) (1.6123441e-05, 0.0003115428) (1.5760999e-05, 0.00031169293) (1.540636e-05, 0.00031186066) (1.5060378e-05, 0.00031204559) (1.4723887e-05, 0.00031224728) (1.4397697e-05, 0.00031246523) (1.4082595e-05, 0.00031269893) (1.3779339e-05, 0.0003129478) (1.348866e-05, 0.00031321126) (1.3211259e-05, 0.00031348866) (1.2947803e-05, 0.00031377934) (1.2698928e-05, 0.00031408259) (1.2465232e-05, 0.0003143977) (1.2247279e-05, 0.00031472389) (1.2045594e-05, 0.00031506038) (1.1860663e-05, 0.00031540636) (1.1692931e-05, 0.000315761) (1.1542802e-05, 0.00031612344) (1.1410639e-05, 0.00031649281) (1.1296759e-05, 0.00031686823) (1.1201436e-05, 0.00031724877) (1.1124902e-05, 0.00031763354) (1.1067338e-05, 0.0003180216) (1.1028886e-05, 0.00031841202) (1.1004817e-05, 0.00031890194) (1.1e-05, 0.00031909818) (1.1e-05, 0.00036690182) (1.1004817e-05, 0.00036709806) (1.1028886e-05, 0.00036758799) (1.1067338e-05, 0.0003679784) (1.1124902e-05, 0.00036836646) (1.1201436e-05, 0.00036875123) (1.1296759e-05, 0.00036913177) (1.1410639e-05, 0.00036950719) (1.1542802e-05, 0.00036987656) (1.1692931e-05, 0.000370239) (1.1860663e-05, 0.00037059364) (1.2045594e-05, 0.00037093962) (1.2247279e-05, 0.00037127611) (1.2465232e-05, 0.0003716023) (1.2698928e-05, 0.0003719174) (1.2947803e-05, 0.00037222066) (1.3211259e-05, 0.00037251134) (1.348866e-05, 0.00037278874) (1.3779339e-05, 0.0003730522) (1.4082595e-05, 0.00037330107) (1.4397697e-05, 0.00037353477) (1.4723887e-05, 0.00037375272) (1.5060378e-05, 0.00037395441) (1.540636e-05, 0.00037413934) (1.5760999e-05, 0.00037430707) (1.6123441e-05, 0.0003744572) (1.6492814e-05, 0.00037458936) (1.6868226e-05, 0.00037470324) (1.7248774e-05, 0.00037479856) (1.7633541e-05, 0.0003748751) (1.80216e-05, 0.00037493266) (1.8412015e-05, 0.00037497111) (1.8901939e-05, 0.00037499518) (1.909818e-05, 0.000375) (0.00012690182, 0.000375) (0.00012709806, 0.00037499518) (0.00012758798, 0.00037497111) (0.0001279784, 0.00037493266) (0.00012836646, 0.0003748751) (0.00012875123, 0.00037479856) (0.00012913177, 0.00037470324) (0.00012950719, 0.00037458936) (0.00012987656, 0.0003744572) (0.000130239, 0.00037430707) (0.00013059364, 0.00037413934) (0.00013093962, 0.00037395441) (0.00013127611, 0.00037375272) (0.0001316023, 0.00037353477) (0.00013191741, 0.00037330107) (0.00013222066, 0.0003730522) (0.00013251134, 0.00037278874) (0.00013278874, 0.00037251134) (0.0001330522, 0.00037222066) (0.00013330107, 0.0003719174) (0.00013353477, 0.0003716023) (0.00013375272, 0.00037127611) (0.00013395441, 0.00037093962) (0.00013413934, 0.00037059364) (0.00013430707, 0.000370239) (0.0001344572, 0.00036987656) (0.00013458936, 0.00036950719) (0.00013470324, 0.00036913177) (0.00013479856, 0.00036875123) (0.0001348751, 0.00036836646) (0.00013493266, 0.0003679784) (0.00013497111, 0.00036758799) (0.00013499518, 0.00036709806) (0.000135, 0.00036690182) (0.000135, 0.00021009818) (0.00013499518, 0.00020990194) (0.00013497111, 0.00020941201) (0.00013493266, 0.0002090216) (0.0001348751, 0.00020863354) (0.00013479856, 0.00020824877) (0.00013470324, 0.00020786823) (0.00013458936, 0.00020749281) (0.0001344572, 0.00020712344) (0.00013430707, 0.000206761) (0.00013413934, 0.00020640636) (0.00013395441, 0.00020606038) (0.00013375272, 0.00020572389) (0.00013353477, 0.0002053977) (0.00013330107, 0.00020508259) (0.0001330522, 0.00020477934) (0.00013278874, 0.00020448866) (0.00013251134, 0.00020421126) (0.00013222066, 0.0002039478) (0.00013191741, 0.00020369893) (0.0001316023, 0.00020346523) (0.00013127611, 0.00020324728) (0.00013093962, 0.00020304559) (0.00013059364, 0.00020286066) (0.000130239, 0.00020269293) (0.00012987656, 0.0002025428) (0.00012950719, 0.00020241064) (0.00012913177, 0.00020229676) (0.00012875123, 0.00020220144) (0.00012836646, 0.0002021249) (0.0001279784, 0.00020206734) (0.00012758798, 0.00020202889) (0.00012709806, 0.00020200482) (0.00012690182, 0.000202) (-0.00012690182, 0.000202) (-0.00012709806, 0.00020200482) (-0.00012758798, 0.00020202889) (-0.0001279784, 0.00020206734) (-0.00012836646, 0.0002021249) (-0.00012875123, 0.00020220144) (-0.00012913177, 0.00020229676) (-0.00012950719, 0.00020241064) (-0.00012987656, 0.0002025428) (-0.000130239, 0.00020269293) (-0.00013059364, 0.00020286066) (-0.00013093962, 0.00020304559) (-0.00013127611, 0.00020324728) (-0.0001316023, 0.00020346523) (-0.00013191741, 0.00020369893) (-0.00013222066, 0.0002039478) (-0.00013251134, 0.00020421126) (-0.00013278874, 0.00020448866) (-0.0001330522, 0.00020477934) (-0.00013330107, 0.00020508259) (-0.00013353477, 0.0002053977) (-0.00013375272, 0.00020572389) (-0.00013395441, 0.00020606038) (-0.00013413934, 0.00020640636) (-0.00013430707, 0.000206761) (-0.0001344572, 0.00020712344) (-0.00013458936, 0.00020749281) (-0.00013470324, 0.00020786823) (-0.00013479856, 0.00020824877) (-0.0001348751, 0.00020863354) (-0.00013493266, 0.0002090216) (-0.00013497111, 0.00020941201) (-0.00013499518, 0.00020990194) (-0.000135, 0.00021009818) (-0.000135, 0.00036690182) (-0.00013499518, 0.00036709806) (-0.00013497111, 0.00036758799) (-0.00013493266, 0.0003679784) (-0.0001348751, 0.00036836646) (-0.00013479856, 0.00036875123) (-0.00013470324, 0.00036913177) (-0.00013458936, 0.00036950719) (-0.0001344572, 0.00036987656) (-0.00013430707, 0.000370239) (-0.00013413934, 0.00037059364) (-0.00013395441, 0.00037093962) (-0.00013375272, 0.00037127611) (-0.00013353477, 0.0003716023) (-0.00013330107, 0.0003719174) (-0.0001330522, 0.00037222066) (-0.00013278874, 0.00037251134) (-0.00013251134, 0.00037278874) (-0.00013222066, 0.0003730522) (-0.00013191741, 0.00037330107) (-0.0001316023, 0.00037353477) (-0.00013127611, 0.00037375272) (-0.00013093962, 0.00037395441) (-0.00013059364, 0.00037413934) (-0.000130239, 0.00037430707) (-0.00012987656, 0.0003744572) (-0.00012950719, 0.00037458936) (-0.00012913177, 0.00037470324) (-0.00012875123, 0.00037479856) (-0.00012836646, 0.0003748751) (-0.0001279784, 0.00037493266) (-0.00012758798, 0.00037497111) (-0.00012709806, 0.00037499518) (-0.00012690182, 0.000375) (-1.909818e-05, 0.000375) (-1.8901939e-05, 0.00037499518) (-1.8412015e-05, 0.00037497111) (-1.80216e-05, 0.00037493266) (-1.7633541e-05, 0.0003748751) (-1.7248774e-05, 0.00037479856) (-1.6868226e-05, 0.00037470324) (-1.6492814e-05, 0.00037458936) (-1.6123441e-05, 0.0003744572) (-1.5760999e-05, 0.00037430707) (-1.540636e-05, 0.00037413934) (-1.5060378e-05, 0.00037395441) (-1.4723887e-05, 0.00037375272) (-1.4397697e-05, 0.00037353477) (-1.4082595e-05, 0.00037330107) (-1.3779339e-05, 0.0003730522) (-1.348866e-05, 0.00037278874) (-1.3211259e-05, 0.00037251134) (-1.2947803e-05, 0.00037222066) (-1.2698928e-05, 0.0003719174) (-1.2465232e-05, 0.0003716023) (-1.2247279e-05, 0.00037127611) (-1.2045594e-05, 0.00037093962) (-1.1860663e-05, 0.00037059364) (-1.1692931e-05, 0.000370239) (-1.1542802e-05, 0.00036987656) (-1.1410639e-05, 0.00036950719) (-1.1296759e-05, 0.00036913177) (-1.1201436e-05, 0.00036875123) (-1.1124902e-05, 0.00036836646) (-1.1067338e-05, 0.0003679784) (-1.1028886e-05, 0.00036758799) (-1.1004817e-05, 0.00036709806) (-1.1e-05, 0.00036690182) (-1.1e-05, 0.00031909818) (-1.1004817e-05, 0.00031890194) (-1.1028886e-05, 0.00031841202) (-1.1067338e-05, 0.0003180216) (-1.1124902e-05, 0.00031763354) (-1.1201436e-05, 0.00031724877) (-1.1296759e-05, 0.00031686823) (-1.1410639e-05, 0.00031649281) (-1.1542802e-05, 0.00031612344) (-1.1692931e-05, 0.000315761) (-1.1860663e-05, 0.00031540636) (-1.2045594e-05, 0.00031506038) (-1.2247279e-05, 0.00031472389) (-1.2465232e-05, 0.0003143977) (-1.2698928e-05, 0.00031408259) (-1.2947803e-05, 0.00031377934) (-1.3211259e-05, 0.00031348866) (-1.348866e-05, 0.00031321126) (-1.3779339e-05, 0.0003129478) (-1.4082595e-05, 0.00031269893) (-1.4397697e-05, 0.00031246523) (-1.4723887e-05, 0.00031224728) (-1.5060378e-05, 0.00031204559) (-1.540636e-05, 0.00031186066) (-1.5760999e-05, 0.00031169293) (-1.6123441e-05, 0.0003115428) (-1.6492814e-05, 0.00031141064) (-1.6868226e-05, 0.00031129676)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, closed, covered)
  pocket_cp = polyline(z=0, xy: (0.000135, 0.00019) (-0.000135, 0.00019) (-0.00013617621, 0.00019005778) (-0.00013734108, 0.00019023058) (-0.00013848342, 0.00019051672) (-0.0001395922, 0.00019091345) (-0.00014065676, 0.00019141694) (-0.00014166684, 0.00019202237) (-0.00014261272, 0.00019272388) (-0.00014348528, 0.00019351472) (-0.00014427613, 0.00019438728) (-0.00014497764, 0.00019533316) (-0.00014558305, 0.00019634324) (-0.00014608655, 0.0001974078) (-0.00014648328, 0.00019851658) (-0.00014676942, 0.00019965892) (-0.00014694222, 0.00020082379) (-0.000147, 0.000202) (-0.000147, 0.000375) (-0.00014694222, 0.00037617621) (-0.00014676942, 0.00037734108) (-0.00014648328, 0.00037848342) (-0.00014608655, 0.0003795922) (-0.00014558305, 0.00038065676) (-0.00014497764, 0.00038166684) (-0.00014427613, 0.00038261272) (-0.00014348528, 0.00038348528) (-0.00014261272, 0.00038427613) (-0.00014166684, 0.00038497764) (-0.00014065676, 0.00038558305) (-0.0001395922, 0.00038608655) (-0.00013848342, 0.00038648328) (-0.00013734108, 0.00038676942) (-0.00013617621, 0.00038694222) (-0.000135, 0.000387) (0.000135, 0.000387) (0.00013617621, 0.00038694222) (0.00013734108, 0.00038676942) (0.00013848342, 0.00038648328) (0.0001395922, 0.00038608655) (0.00014065676, 0.00038558305) (0.00014166684, 0.00038497764) (0.00014261272, 0.00038427613) (0.00014348528, 0.00038348528) (0.00014427613, 0.00038261272) (0.00014497764, 0.00038166684) (0.00014558305, 0.00038065676) (0.00014608655, 0.0003795922) (0.00014648328, 0.00037848342) (0.00014676942, 0.00037734108) (0.00014694222, 0.00037617621) (0.000147, 0.000375) (0.000147, 0.000202) (0.00014694222, 0.00020082379) (0.00014676942, 0.00019965892) (0.00014648328, 0.00019851658) (0.00014608655, 0.0001974078) (0.00014558305, 0.00019634324) (0.00014497764, 0.00019533316) (0.00014427613, 0.00019438728) (0.00014348528, 0.00019351472) (0.00014261272, 0.00019272388) (0.00014166684, 0.00019202237) (0.00014065676, 0.00019141694) (0.0001395922, 0.00019091345) (0.00013848342, 0.00019051672) (0.00013734108, 0.00019023058) (0.00013617621, 0.00019005778) (0.000135, 0.00019), closed, covered)
  tap_trace_jf = polyline(z=0, xy: (-5e-06, 0.001465) (-5e-06, 0.001765) (5e-06, 0.001765) (5e-06, 0.00162) (7.55e-05, 0.00162) (7.55e-05, 0.00161) (5e-06, 0.00161) (5e-06, 0.001465) (-5e-06, 0.001465), closed, covered)
  tap_cut_jf = polyline(z=0, xy: (-1.1e-05, 0.001465) (-1.1e-05, 0.001765) (1.1e-05, 0.001765) (1.1e-05, 0.001626) (7.55e-05, 0.001626) (7.55e-05, 0.001604) (1.1e-05, 0.001604) (1.1e-05, 0.001465) (-1.1e-05, 0.001465), closed, covered)
  tap_trace_jr = polyline(z=0, xy: (0.0001745, 0.00162) (0.000245, 0.00162) (0.000245, 0.001765) (0.000255, 0.001765) (0.000255, 0.001465) (0.000245, 0.001465) (0.000245, 0.00161) (0.0001745, 0.00161) (0.0001745, 0.00162), closed, covered)
  tap_cut_jr = polyline(z=0, xy: (0.0001745, 0.001626) (0.000239, 0.001626) (0.000239, 0.001765) (0.000261, 0.001765) (0.000261, 0.001465) (0.000239, 0.001465) (0.000239, 0.001604) (0.0001745, 0.001604) (0.0001745, 0.001626), closed, covered)
  head_a_cj = polyline(z=0, xy: (0.0001075, 0.001596) (0.00010730397, 0.0015960096) (0.00010710982, 0.0015960384) (0.00010691943, 0.0015960861) (0.00010673463, 0.0015961522) (0.00010655721, 0.0015962362) (0.00010638886, 0.0015963371) (0.00010623121, 0.001596454) (0.00010608579, 0.0015965858) (0.00010595398, 0.0015967312) (0.00010583706, 0.0015968889) (0.00010573616, 0.0015970572) (0.00010565224, 0.0015972346) (0.00010558612, 0.0015974194) (0.00010553843, 0.0015976098) (0.00010550963, 0.001597804) (0.0001055, 0.001598) (0.0001055, 0.001632) (0.00010550963, 0.001632196) (0.00010553843, 0.0016323902) (0.00010558612, 0.0016325806) (0.00010565224, 0.0016327654) (0.00010573616, 0.0016329428) (0.00010583706, 0.0016331111) (0.00010595398, 0.0016332688) (0.00010608579, 0.0016334142) (0.00010623121, 0.001633546) (0.00010638886, 0.0016336629) (0.00010655721, 0.0016337638) (0.00010673463, 0.0016338478) (0.00010691943, 0.0016339139) (0.00010710982, 0.0016339616) (0.00010730397, 0.0016339904) (0.0001075, 0.001634) (0.0001185, 0.001634) (0.00011869603, 0.0016339904) (0.00011889018, 0.0016339616) (0.00011908057, 0.0016339139) (0.00011926537, 0.0016338478) (0.00011944279, 0.0016337638) (0.00011961114, 0.0016336629) (0.00011976879, 0.001633546) (0.00011991421, 0.0016334142) (0.00012004602, 0.0016332688) (0.00012016294, 0.0016331111) (0.00012026384, 0.0016329428) (0.00012034776, 0.0016327654) (0.00012041388, 0.0016325806) (0.00012046157, 0.0016323902) (0.00012049037, 0.001632196) (0.0001205, 0.001632) (0.0001205, 0.001598) (0.00012049037, 0.001597804) (0.00012046157, 0.0015976098) (0.00012041388, 0.0015974194) (0.00012034776, 0.0015972346) (0.00012026384, 0.0015970572) (0.00012016294, 0.0015968889) (0.00012004602, 0.0015967312) (0.00011991421, 0.0015965858) (0.00011976879, 0.001596454) (0.00011961114, 0.0015963371) (0.00011944279, 0.0015962362) (0.00011926537, 0.0015961522) (0.00011908057, 0.0015960861) (0.00011889018, 0.0015960384) (0.00011869603, 0.0015960096) (0.0001185, 0.001596) (0.0001075, 0.001596), closed, covered)
  head_b_cj = polyline(z=0, xy: (0.0001315, 0.001596) (0.00013130397, 0.0015960096) (0.00013110982, 0.0015960384) (0.00013091943, 0.0015960861) (0.00013073463, 0.0015961522) (0.00013055721, 0.0015962362) (0.00013038886, 0.0015963371) (0.00013023121, 0.001596454) (0.00013008579, 0.0015965858) (0.00012995398, 0.0015967312) (0.00012983706, 0.0015968889) (0.00012973616, 0.0015970572) (0.00012965224, 0.0015972346) (0.00012958612, 0.0015974194) (0.00012953843, 0.0015976098) (0.00012950963, 0.001597804) (0.0001295, 0.001598) (0.0001295, 0.001632) (0.00012950963, 0.001632196) (0.00012953843, 0.0016323902) (0.00012958612, 0.0016325806) (0.00012965224, 0.0016327654) (0.00012973616, 0.0016329428) (0.00012983706, 0.0016331111) (0.00012995398, 0.0016332688) (0.00013008579, 0.0016334142) (0.00013023121, 0.001633546) (0.00013038886, 0.0016336629) (0.00013055721, 0.0016337638) (0.00013073463, 0.0016338478) (0.00013091943, 0.0016339139) (0.00013110982, 0.0016339616) (0.00013130397, 0.0016339904) (0.0001315, 0.001634) (0.0001425, 0.001634) (0.00014269603, 0.0016339904) (0.00014289018, 0.0016339616) (0.00014308057, 0.0016339139) (0.00014326537, 0.0016338478) (0.00014344279, 0.0016337638) (0.00014361114, 0.0016336629) (0.00014376879, 0.001633546) (0.00014391421, 0.0016334142) (0.00014404602, 0.0016332688) (0.00014416294, 0.0016331111) (0.00014426384, 0.0016329428) (0.00014434776, 0.0016327654) (0.00014441388, 0.0016325806) (0.00014446157, 0.0016323902) (0.00014449037, 0.001632196) (0.0001445, 0.001632) (0.0001445, 0.001598) (0.00014449037, 0.001597804) (0.00014446157, 0.0015976098) (0.00014441388, 0.0015974194) (0.00014434776, 0.0015972346) (0.00014426384, 0.0015970572) (0.00014416294, 0.0015968889) (0.00014404602, 0.0015967312) (0.00014391421, 0.0015965858) (0.00014376879, 0.001596454) (0.00014361114, 0.0015963371) (0.00014344279, 0.0015962362) (0.00014326537, 0.0015961522) (0.00014308057, 0.0015960861) (0.00014289018, 0.0015960384) (0.00014269603, 0.0015960096) (0.0001425, 0.001596) (0.0001315, 0.001596), closed, covered)
  pocket_cj = polyline(z=0, xy: (9.75e-05, 0.001586) (9.7303966e-05, 0.0015860096) (9.7109819e-05, 0.0015860384) (9.6919431e-05, 0.0015860861) (9.6734633e-05, 0.0015861522) (9.6557207e-05, 0.0015862362) (9.638886e-05, 0.0015863371) (9.6231213e-05, 0.001586454) (9.6085786e-05, 0.0015865858) (9.5953979e-05, 0.0015867312) (9.5837061e-05, 0.0015868889) (9.5736157e-05, 0.0015870572) (9.5652241e-05, 0.0015872346) (9.5586119e-05, 0.0015874194) (9.5538429e-05, 0.0015876098) (9.5509631e-05, 0.001587804) (9.55e-05, 0.001588) (9.55e-05, 0.001642) (9.5509631e-05, 0.001642196) (9.5538429e-05, 0.0016423902) (9.5586119e-05, 0.0016425806) (9.5652241e-05, 0.0016427654) (9.5736157e-05, 0.0016429428) (9.5837061e-05, 0.0016431111) (9.5953979e-05, 0.0016432688) (9.6085786e-05, 0.0016434142) (9.6231213e-05, 0.001643546) (9.638886e-05, 0.0016436629) (9.6557207e-05, 0.0016437638) (9.6734633e-05, 0.0016438478) (9.6919431e-05, 0.0016439139) (9.7109819e-05, 0.0016439616) (9.7303966e-05, 0.0016439904) (9.75e-05, 0.001644) (0.0001525, 0.001644) (0.00015269603, 0.0016439904) (0.00015289018, 0.0016439616) (0.00015308057, 0.0016439139) (0.00015326537, 0.0016438478) (0.00015344279, 0.0016437638) (0.00015361114, 0.0016436629) (0.00015376879, 0.001643546) (0.00015391421, 0.0016434142) (0.00015404602, 0.0016432688) (0.00015416294, 0.0016431111) (0.00015426384, 0.0016429428) (0.00015434776, 0.0016427654) (0.00015441388, 0.0016425806) (0.00015446157, 0.0016423902) (0.00015449037, 0.001642196) (0.0001545, 0.001642) (0.0001545, 0.001588) (0.00015449037, 0.001587804) (0.00015446157, 0.0015876098) (0.00015441388, 0.0015874194) (0.00015434776, 0.0015872346) (0.00015426384, 0.0015870572) (0.00015416294, 0.0015868889) (0.00015404602, 0.0015867312) (0.00015391421, 0.0015865858) (0.00015376879, 0.001586454) (0.00015361114, 0.0015863371) (0.00015344279, 0.0015862362) (0.00015326537, 0.0015861522) (0.00015308057, 0.0015860861) (0.00015289018, 0.0015860384) (0.00015269603, 0.0015860096) (0.0001525, 0.001586) (9.75e-05, 0.001586), closed, covered)
  open_to_ground_readout_open = rectangle(corner=(0.000239, 0.002915, 0), x_size=2.2e-05, y_size=6e-06)
  endcap_feed_in_start = rectangle(corner=(-0.001626, -1.1e-05, 0), x_size=6e-06, y_size=2.2e-05)
  endcap_feed_out_end = rectangle(corner=(0.00162, -1.1e-05, 0), x_size=6e-06, y_size=2.2e-05)
  ground_main_plane = rectangle(corner=(-0.00182, -0.000347, 0), x_size=0.00364, y_size=0.003468)
  main [silicon_eps11p45] = box(corner=(-0.00182, -0.000347, -0.0005), size=(0.00364, 0.003468, 0.0005))
  sample_holder [vacuum] = box(corner=(-0.00182, -0.000347, -0.00165), size=(0.00364, 0.003468, 0.00254))
  ground_main_plane.subtract(cut_filter_tail, lead_a_sub_cp, cut_stub_r, pocket_cj, lead_a_sub_cj, open_to_ground_readout_open, tap_cut_jr, cut_feed_out, pocket_cp, cut_stub_p, lead_b_sub_cin, cut_stub_f, endcap_feed_out_end, cut_res_open_run, endcap_feed_in_start, lead_b_sub_cj, lead_b_sub_cp, cut_feed_jf, lead_a_sub_cin, cut_feed_in, pocket_cin, cut_res_tail, tap_cut_n0, tap_cut_jf, cut_feed_mid)
  Port_feed_in_start = rectangle(corner=(-0.001626, -5e-06, 0), x_size=6e-06, y_size=1e-05)
  voltage_line_Port_feed_in_start = polyline((-0.00162, 0, 0) (-0.001626, 0, 0))
  Port_feed_out_end = rectangle(corner=(0.00162, -5e-06, 0), x_size=6e-06, y_size=1e-05)
  voltage_line_Port_feed_out_end = polyline((0.00162, 0, 0) (0.001626, 0, 0))
  g_wb [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=5.325e-05 YPadPos=0.001585 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_1 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00019675 YPadPos=0.001585 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_2 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-3.05e-05 YPadPos=3e-05 ZPadPos=0 XDir=0 YDir=-1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_3 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=3.05e-05 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_4 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=3e-05 YPadPos=6.45e-05 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_5 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.0007664995 YPadPos=3e-05 ZPadPos=0 XDir=0 YDir=-1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_6 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-3e-05 YPadPos=0.0001760005 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_7 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.0014940625 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_8 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.0013021875 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_9 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.0011103125 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_10 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.0009184375 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_11 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000418125 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_12 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000259375 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_13 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000268125 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_14 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000444375 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_15 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000620625 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_16 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000796875 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_17 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000973125 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_18 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.001149375 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_19 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.001325625 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_20 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.001501875 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_21 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=3e-05 YPadPos=0.000125 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_22 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=8.55e-05 YPadPos=0.001585 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_23 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.0001645 YPadPos=0.001585 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_24 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=3e-05 YPadPos=0.000544 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_25 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=3e-05 YPadPos=0.000742 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_26 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=3e-05 YPadPos=0.00094 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_27 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=3e-05 YPadPos=0.001138 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_28 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=3e-05 YPadPos=0.001336 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_29 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00028 YPadPos=0.0018858333 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_30 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00028 YPadPos=0.0020675 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_31 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00028 YPadPos=0.0022491667 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_32 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00028 YPadPos=0.0024308333 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_33 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00028 YPadPos=0.0026125 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_34 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00028 YPadPos=0.0027941667 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_35 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=3e-05 YPadPos=0.00189275 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_36 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=3e-05 YPadPos=0.00208825 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_37 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00017930847 YPadPos=0.002315 ZPadPos=0 XDir=0 YDir=-1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_38 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.0003399254 YPadPos=0.002315 ZPadPos=0 XDir=0 YDir=-1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_39 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00054923387 YPadPos=0.00217 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_40 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00038461694 YPadPos=0.002025 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_41 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00028 YPadPos=0.00194 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_42 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00038461694 YPadPos=0.001855 ZPadPos=0 XDir=0 YDir=-1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_43 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00054923387 YPadPos=0.00171 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_44 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00038461694 YPadPos=0.001565 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_45 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00028 YPadPos=0.00148 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_46 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00038461694 YPadPos=0.001395 ZPadPos=0 XDir=0 YDir=-1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_47 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00054923387 YPadPos=0.0012155 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_48 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00022 YPadPos=0.0013398333 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_49 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00022 YPadPos=0.0011495 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_50 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00022 YPadPos=0.00095916667 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_51 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00043104423 YPadPos=0.000735 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_52 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.0005951327 YPadPos=0.000735 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_53 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00080617693 YPadPos=0.00088 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_54 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00063808846 YPadPos=0.001025 ZPadPos=0 XDir=0 YDir=-1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_55 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00053 YPadPos=0.00111 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_56 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00063808846 YPadPos=0.001195 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_57 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00080617693 YPadPos=0.00134 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_58 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00063808846 YPadPos=0.001485 ZPadPos=0 XDir=0 YDir=-1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_59 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00053 YPadPos=0.00157 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_60 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00063808846 YPadPos=0.001655 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_61 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00080617693 YPadPos=0.00183 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
boundaries and excitations:
  RLCBoundary_feed_in_start: Lumped RLC Objects=Port_feed_in_start CurrentLine{middle of Port_feed_in_start.edge(x at corner) -> middle of Port_feed_in_start.edge(x opposite corner)} RLC_Type=Parallel Resistance=50ohm
  RLCBoundary_feed_out_end: Lumped RLC Objects=Port_feed_out_end CurrentLine{middle of Port_feed_out_end.edge(x at corner) -> middle of Port_feed_out_end.edge(x opposite corner)} RLC_Type=Parallel Resistance=50ohm
  PerfE: Perfect E Objects=[lead_a_cin, lead_b_cin, lead_a_cp, lead_b_cp, trace_feed_in, trace_feed_mid, trace_feed_out, trace_stub_p, lead_a_cj, lead_b_cj, trace_stub_f, trace_stub_r, trace_feed_jf, trace_res_open_run, trace_filter_tail, trace_res_tail, plate_cin, frame_cin, tap_trace_n0, plate_cp, frame_cp, tap_trace_jf, tap_trace_jr, head_a_cj, head_b_cj, ground_main_plane]
mesh:
  port_mesh: LengthBased Objects=[Port_feed_in_start, Port_feed_out_end] MaxLength=7um
  cpw_line_mesh: LengthBased Objects=[lead_a_cin, lead_b_cin, trace_feed_in, trace_feed_mid, trace_feed_out, trace_stub_p, trace_stub_f, trace_stub_r, trace_feed_jf, trace_res_open_run, trace_filter_tail, trace_res_tail, plate_cin, frame_cin, tap_trace_n0, tap_trace_jf, tap_trace_jr] MaxLength=20um
  cap_mesh: LengthBased Objects=[lead_a_cp, lead_b_cp, lead_a_cj, lead_b_cj, plate_cp, frame_cp, head_a_cj, head_b_cj] MaxLength=9um
setups:
  Setup: HfssEigen MinimumFrequency=5.95GHz NumModes=2 MaxDeltaFreq=0.1 ConvergeOnRealFreq=true MaximumPasses=8 MinimumPasses=3 MinimumConvergedPasses=2 PercentRefinement=20 BasisOrder=1
source amplitudes:
  #-10:1: 1 0deg
  #-10:2: 0 0deg
reports:
  Freq. vs. pass: re(Mode(1)), re(Mode(2)) vs Pass on Setup : AdaptivePass

design P250g9_cpwwb_p30um_2038_hfss (HFSS, Eigenmode, model units mm)
geometry:
  lead_a_cin_path = polyline((-0.000740499, 0, 0) (-0.0007925, 0, 0))
  lead_a_cin = polyline((-0.000740499, -5e-06, 0) (-0.000740499, 5e-06, 0))
  lead_a_cin.sweep_along_path(lead_a_cin_path)
  lead_a_sub_cin_path = polyline((-0.000740499, 0, 0) (-0.0007925, 0, 0))
  lead_a_sub_cin = polyline((-0.000740499, -1.1e-05, 0) (-0.000740499, 1.1e-05, 0))
  lead_a_sub_cin.sweep_along_path(lead_a_sub_cin_path)
  lead_b_cin_path = polyline((-0.000639501, 0, 0) (-0.0005275, 0, 0))
  lead_b_cin = polyline((-0.000639501, 5e-06, 0) (-0.000639501, -5e-06, 0))
  lead_b_cin.sweep_along_path(lead_b_cin_path)
  lead_b_sub_cin_path = polyline((-0.000639501, 0, 0) (-0.0005275, 0, 0))
  lead_b_sub_cin = polyline((-0.000639501, 1.1e-05, 0) (-0.000639501, -1.1e-05, 0))
  lead_b_sub_cin.sweep_along_path(lead_b_sub_cin_path)
  lead_a_cp_path = polyline((0, 0.000202001, 0) (0, 0.00015, 0))
  lead_a_cp = polyline((5e-06, 0.000202001, 0) (-5e-06, 0.000202001, 0))
  lead_a_cp.sweep_along_path(lead_a_cp_path)
  lead_a_sub_cp_path = polyline((0, 0.000202001, 0) (0, 0.00015, 0))
  lead_a_sub_cp = polyline((1.1e-05, 0.000202001, 0) (-1.1e-05, 0.000202001, 0))
  lead_a_sub_cp.sweep_along_path(lead_a_sub_cp_path)
  lead_b_cp_path = polyline((0, 0.000302999, 0) (0, 0.000415, 0))
  lead_b_cp = polyline((-5e-06, 0.000302999, 0) (5e-06, 0.000302999, 0))
  lead_b_cp.sweep_along_path(lead_b_cp_path)
  lead_b_sub_cp_path = polyline((0, 0.000302999, 0) (0, 0.000415, 0))
  lead_b_sub_cp = polyline((-1.1e-05, 0.000302999, 0) (1.1e-05, 0.000302999, 0))
  lead_b_sub_cp.sweep_along_path(lead_b_sub_cp_path)
  trace_feed_in_path = polyline((-0.00162, 0, 0) (-0.0007925, 0, 0))
  trace_feed_in = polyline((-0.00162, 5e-06, 0) (-0.00162, -5e-06, 0))
  trace_feed_in.sweep_along_path(trace_feed_in_path)
  cut_feed_in_path = polyline((-0.00162, 0, 0) (-0.0007925, 0, 0))
  cut_feed_in = polyline((-0.00162, 1.1e-05, 0) (-0.00162, -1.1e-05, 0))
  cut_feed_in.sweep_along_path(cut_feed_in_path)
  trace_feed_mid_path = polyline((-0.0005275, 0, 0) (-0.00015, 0, 0))
  trace_feed_mid = polyline((-0.0005275, 5e-06, 0) (-0.0005275, -5e-06, 0))
  trace_feed_mid.sweep_along_path(trace_feed_mid_path)
  cut_feed_mid_path = polyline((-0.0005275, 0, 0) (-0.00015, 0, 0))
  cut_feed_mid = polyline((-0.0005275, 1.1e-05, 0) (-0.0005275, -1.1e-05, 0))
  cut_feed_mid.sweep_along_path(cut_feed_mid_path)
  trace_feed_out_path = polyline((0.00015, 0, 0) (0.00162, 0, 0))
  trace_feed_out = polyline((0.00015, 5e-06, 0) (0.00015, -5e-06, 0))
  trace_feed_out.sweep_along_path(trace_feed_out_path)
  cut_feed_out_path = polyline((0.00015, 0, 0) (0.00162, 0, 0))
  cut_feed_out = polyline((0.00015, 1.1e-05, 0) (0.00015, -1.1e-05, 0))
  cut_feed_out.sweep_along_path(cut_feed_out_path)
  trace_stub_p_path = polyline((0, 0.0001, 0) (0, 0.00015, 0))
  trace_stub_p = polyline((-5e-06, 0.0001, 0) (5e-06, 0.0001, 0))
  trace_stub_p.sweep_along_path(trace_stub_p_path)
  cut_stub_p_path = polyline((0, 0.0001, 0) (0, 0.00015, 0))
  cut_stub_p = polyline((-1.1e-05, 0.0001, 0) (1.1e-05, 0.0001, 0))
  cut_stub_p.sweep_along_path(cut_stub_p_path)
  lead_a_cj_path = polyline((0.000105501, 0.001615, 0) (9.55e-05, 0.001615, 0))
  lead_a_cj = polyline((0.000105501, 0.00161, 0) (0.000105501, 0.00162, 0))
  lead_a_cj.sweep_along_path(lead_a_cj_path)
  lead_a_sub_cj_path = polyline((0.000105501, 0.001615, 0) (9.55e-05, 0.001615, 0))
  lead_a_sub_cj = polyline((0.000105501, 0.001604, 0) (0.000105501, 0.001626, 0))
  lead_a_sub_cj.sweep_along_path(lead_a_sub_cj_path)
  lead_b_cj_path = polyline((0.000144499, 0.001615, 0) (0.0001545, 0.001615, 0))
  lead_b_cj = polyline((0.000144499, 0.00162, 0) (0.000144499, 0.00161, 0))
  lead_b_cj.sweep_along_path(lead_b_cj_path)
  lead_b_sub_cj_path = polyline((0.000144499, 0.001615, 0) (0.0001545, 0.001615, 0))
  lead_b_sub_cj = polyline((0.000144499, 0.001626, 0) (0.000144499, 0.001604, 0))
  lead_b_sub_cj.sweep_along_path(lead_b_sub_cj_path)
  trace_stub_f_path = polyline((7.55e-05, 0.001615, 0) (9.55e-05, 0.001615, 0))
  trace_stub_f = polyline((7.55e-05, 0.00162, 0) (7.55e-05, 0.00161, 0))
  trace_stub_f.sweep_along_path(trace_stub_f_path)
  cut_stub_f_path = polyline((7.55e-05, 0.001615, 0) (9.55e-05, 0.001615, 0))
  cut_stub_f = polyline((7.55e-05, 0.001626, 0) (7.55e-05, 0.001604, 0))
  cut_stub_f.sweep_along_path(cut_stub_f_path)
  trace_stub_r_path = polyline((0.0001545, 0.001615, 0) (0.0001745, 0.001615, 0))
  trace_stub_r = polyline((0.0001545, 0.00162, 0) (0.0001545, 0.00161, 0))
  trace_stub_r.sweep_along_path(trace_stub_r_path)
  cut_stub_r_path = polyline((0.0001545, 0.001615, 0) (0.0001745, 0.001615, 0))
  cut_stub_r = polyline((0.0001545, 0.001626, 0) (0.0001545, 0.001604, 0))
  cut_stub_r.sweep_along_path(cut_stub_r_path)
  trace_feed_jf_path = polyline((0, 0.000415, 0) (0, 0.001465, 0))
  trace_feed_jf = polyline((-5e-06, 0.000415, 0) (5e-06, 0.000415, 0))
  trace_feed_jf.sweep_along_path(trace_feed_jf_path)
  cut_feed_jf_path = polyline((0, 0.000415, 0) (0, 0.001465, 0))
  cut_feed_jf = polyline((-1.1e-05, 0.000415, 0) (1.1e-05, 0.000415, 0))
  cut_feed_jf.sweep_along_path(cut_feed_jf_path)
  trace_res_open_run_path = polyline((0.00025, 0.001765, 0) (0.00025, 0.002915, 0))
  trace_res_open_run = polyline((0.000245, 0.001765, 0) (0.000255, 0.001765, 0))
  trace_res_open_run.sweep_along_path(trace_res_open_run_path)
  cut_res_open_run_path = polyline((0.00025, 0.001765, 0) (0.00025, 0.002915, 0))
  cut_res_open_run = polyline((0.000239, 0.001765, 0) (0.000261, 0.001765, 0))
  cut_res_open_run.sweep_along_path(cut_res_open_run_path)
  trace_filter_tail_path = polyline(z=0, xy: (0, 0.001765) (0, 0.002285) (-0.00051923387, 0.002285) (-0.00051923387, 0.002055) (-0.00025, 0.002055) (-0.00025, 0.001825) (-0.00051923387, 0.001825) (-0.00051923387, 0.001595) (-0.00025, 0.001595) (-0.00025, 0.001365) (-0.00051923387, 0.001365) (-0.00051923387, 0.001135))
  trace_filter_tail_path.fillet(Vertices=trace_filter_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  trace_filter_tail = polyline((-5e-06, 0.001765, 0) (5e-06, 0.001765, 0))
  trace_filter_tail.sweep_along_path(trace_filter_tail_path)
  cut_filter_tail_path = polyline(z=0, xy: (0, 0.001765) (0, 0.002285) (-0.00051923387, 0.002285) (-0.00051923387, 0.002055) (-0.00025, 0.002055) (-0.00025, 0.001825) (-0.00051923387, 0.001825) (-0.00051923387, 0.001595) (-0.00025, 0.001595) (-0.00025, 0.001365) (-0.00051923387, 0.001365) (-0.00051923387, 0.001135))
  cut_filter_tail_path.fillet(Vertices=cut_filter_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  cut_filter_tail = polyline((-1.1e-05, 0.001765, 0) (1.1e-05, 0.001765, 0))
  cut_filter_tail.sweep_along_path(cut_filter_tail_path)
  trace_res_tail_path = polyline(z=0, xy: (0.00025, 0.001465) (0.00025, 0.000765) (0.00077617693, 0.000765) (0.00077617693, 0.000995) (0.0005, 0.000995) (0.0005, 0.001225) (0.00077617693, 0.001225) (0.00077617693, 0.001455) (0.0005, 0.001455) (0.0005, 0.001685) (0.00077617693, 0.001685) (0.00077617693, 0.001945))
  trace_res_tail_path.fillet(Vertices=trace_res_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  trace_res_tail = polyline((0.000255, 0.001465, 0) (0.000245, 0.001465, 0))
  trace_res_tail.sweep_along_path(trace_res_tail_path)
  cut_res_tail_path = polyline(z=0, xy: (0.00025, 0.001465) (0.00025, 0.000765) (0.00077617693, 0.000765) (0.00077617693, 0.000995) (0.0005, 0.000995) (0.0005, 0.001225) (0.00077617693, 0.001225) (0.00077617693, 0.001455) (0.0005, 0.001455) (0.0005, 0.001685) (0.00077617693, 0.001685) (0.00077617693, 0.001945))
  cut_res_tail_path.fillet(Vertices=cut_res_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  cut_res_tail = polyline((0.000261, 0.001465, 0) (0.000239, 0.001465, 0))
  cut_res_tail.sweep_along_path(cut_res_tail_path)
  plate_cin = polyline(z=0, xy: (-0.0006725, -7e-05) (-0.00067328414, -6.9961478e-05) (-0.00067406072, -6.9846282e-05) (-0.00067482228, -6.9655523e-05) (-0.00067556147, -6.9391036e-05) (-0.00067627117, -6.905537e-05) (-0.00067694456, -6.8651757e-05) (-0.00067757515, -6.8184084e-05) (-0.00067815685, -6.7656854e-05) (-0.00067868408, -6.7075146e-05) (-0.00067915176, -6.6444562e-05) (-0.00067955537, -6.5771174e-05) (-0.00067989104, -6.5061467e-05) (-0.00068015552, -6.4322277e-05) (-0.00068034628, -6.3560723e-05) (-0.00068046148, -6.2784137e-05) (-0.0006805, -6.2e-05) (-0.0006805, 6.2e-05) (-0.00068046148, 6.2784137e-05) (-0.00068034628, 6.3560723e-05) (-0.00068015552, 6.4322277e-05) (-0.00067989104, 6.5061467e-05) (-0.00067955537, 6.5771174e-05) (-0.00067915176, 6.6444562e-05) (-0.00067868408, 6.7075146e-05) (-0.00067815685, 6.7656854e-05) (-0.00067757515, 6.8184084e-05) (-0.00067694456, 6.8651757e-05) (-0.00067627117, 6.905537e-05) (-0.00067556147, 6.9391036e-05) (-0.00067482228, 6.9655523e-05) (-0.00067406072, 6.9846282e-05) (-0.00067328414, 6.9961478e-05) (-0.0006725, 7e-05) (-0.0006475, 7e-05) (-0.00064671586, 6.9961478e-05) (-0.00064593928, 6.9846282e-05) (-0.00064517772, 6.9655523e-05) (-0.00064443853, 6.9391036e-05) (-0.00064372883, 6.905537e-05) (-0.00064305544, 6.8651757e-05) (-0.00064242485, 6.8184084e-05) (-0.00064184315, 6.7656854e-05) (-0.00064131592, 6.7075146e-05) (-0.00064084824, 6.6444562e-05) (-0.00064044463, 6.5771174e-05) (-0.00064010896, 6.5061467e-05) (-0.00063984448, 6.4322277e-05) (-0.00063965372, 6.3560723e-05) (-0.00063953852, 6.2784137e-05) (-0.0006395, 6.2e-05) (-0.0006395, -6.2e-05) (-0.00063953852, -6.2784137e-05) (-0.00063965372, -6.3560723e-05) (-0.00063984448, -6.4322277e-05) (-0.00064010896, -6.5061467e-05) (-0.00064044463, -6.5771174e-05) (-0.00064084824, -6.6444562e-05) (-0.00064131592, -6.7075146e-05) (-0.00064184315, -6.7656854e-05) (-0.00064242485, -6.8184084e-05) (-0.00064305544, -6.8651757e-05) (-0.00064372883, -6.905537e-05) (-0.00064443853, -6.9391036e-05) (-0.00064517772, -6.9655523e-05) (-0.00064593928, -6.9846282e-05) (-0.00064671586, -6.9961478e-05) (-0.0006475, -7e-05) (-0.0006725, -7e-05), closed, covered)
  frame_cin = polyline(z=0, xy: (-0.0006885, -7e-05) (-0.00068846148, -7.0784137e-05) (-0.00068834628, -7.1560723e-05) (-0.00068815552, -7.2322277e-05) (-0.00068789104, -7.3061467e-05) (-0.00068755537, -7.3771174e-05) (-0.00068715176, -7.4444562e-05) (-0.00068668408, -7.5075146e-05) (-0.00068615685, -7.5656854e-05) (-0.00068557515, -7.6184084e-05) (-0.00068494456, -7.6651757e-05) (-0.00068427117, -7.705537e-05) (-0.00068356147, -7.7391036e-05) (-0.00068282228, -7.7655523e-05) (-0.00068206072, -7.7846282e-05) (-0.00068128414, -7.7961478e-05) (-0.0006805, -7.8e-05) (-0.0006395, -7.8e-05) (-0.00063871586, -7.7961478e-05) (-0.00063793928, -7.7846282e-05) (-0.00063717772, -7.7655523e-05) (-0.00063643853, -7.7391036e-05) (-0.00063572883, -7.705537e-05) (-0.00063505544, -7.6651757e-05) (-0.00063442485, -7.6184084e-05) (-0.00063384315, -7.5656854e-05) (-0.00063331592, -7.5075146e-05) (-0.00063284824, -7.4444562e-05) (-0.00063244463, -7.3771174e-05) (-0.00063210896, -7.3061467e-05) (-0.00063184448, -7.2322277e-05) (-0.00063165372, -7.1560723e-05) (-0.00063153852, -7.0784137e-05) (-0.0006315, -7e-05) (-0.0006315, -1.909818e-05) (-0.00063149518, -1.8901939e-05) (-0.00063147111, -1.8412015e-05) (-0.00063143266, -1.80216e-05) (-0.0006313751, -1.7633541e-05) (-0.00063129856, -1.7248774e-05) (-0.00063120324, -1.6868226e-05) (-0.00063108936, -1.6492814e-05) (-0.0006309572, -1.6123441e-05) (-0.00063080707, -1.5760999e-05) (-0.00063063934, -1.540636e-05) (-0.00063045441, -1.5060378e-05) (-0.00063025272, -1.4723887e-05) (-0.00063003477, -1.4397697e-05) (-0.00062980107, -1.4082595e-05) (-0.0006295522, -1.3779339e-05) (-0.00062928874, -1.348866e-05) (-0.00062901134, -1.3211259e-05) (-0.00062872066, -1.2947803e-05) (-0.00062841741, -1.2698928e-05) (-0.0006281023, -1.2465232e-05) (-0.00062777611, -1.2247279e-05) (-0.00062743962, -1.2045594e-05) (-0.00062709364, -1.1860663e-05) (-0.000626739, -1.1692931e-05) (-0.00062637656, -1.1542802e-05) (-0.00062600719, -1.1410639e-05) (-0.00062563177, -1.1296759e-05) (-0.00062525123, -1.1201436e-05) (-0.00062486646, -1.1124902e-05) (-0.0006244784, -1.1067338e-05) (-0.00062408799, -1.1028886e-05) (-0.00062359806, -1.1004817e-05) (-0.00062340182, -1.1e-05) (-0.00057559818, -1.1e-05) (-0.00057540194, -1.1004817e-05) (-0.00057491201, -1.1028886e-05) (-0.0005745216, -1.1067338e-05) (-0.00057413354, -1.1124902e-05) (-0.00057374877, -1.1201436e-05) (-0.00057336823, -1.1296759e-05) (-0.00057299281, -1.1410639e-05) (-0.00057262344, -1.1542802e-05) (-0.000572261, -1.1692931e-05) (-0.00057190636, -1.1860663e-05) (-0.00057156038, -1.2045594e-05) (-0.00057122389, -1.2247279e-05) (-0.0005708977, -1.2465232e-05) (-0.0005705826, -1.2698928e-05) (-0.00057027934, -1.2947803e-05) (-0.00056998866, -1.3211259e-05) (-0.00056971126, -1.348866e-05) (-0.0005694478, -1.3779339e-05) (-0.00056919893, -1.4082595e-05) (-0.00056896523, -1.4397697e-05) (-0.00056874728, -1.4723887e-05) (-0.00056854559, -1.5060378e-05) (-0.00056836066, -1.540636e-05) (-0.00056819293, -1.5760999e-05) (-0.0005680428, -1.6123441e-05) (-0.00056791064, -1.6492814e-05) (-0.00056779676, -1.6868226e-05) (-0.00056770144, -1.7248774e-05) (-0.0005676249, -1.7633541e-05) (-0.00056756734, -1.80216e-05) (-0.00056752889, -1.8412015e-05) (-0.00056750482, -1.8901939e-05) (-0.0005675, -1.909818e-05) (-0.0005675, -0.00012690182) (-0.00056750482, -0.00012709806) (-0.00056752889, -0.00012758798) (-0.00056756734, -0.0001279784) (-0.0005676249, -0.00012836646) (-0.00056770144, -0.00012875123) (-0.00056779676, -0.00012913177) (-0.00056791064, -0.00012950719) (-0.0005680428, -0.00012987656) (-0.00056819293, -0.000130239) (-0.00056836066, -0.00013059364) (-0.00056854559, -0.00013093962) (-0.00056874728, -0.00013127611) (-0.00056896523, -0.0001316023) (-0.00056919893, -0.00013191741) (-0.0005694478, -0.00013222066) (-0.00056971126, -0.00013251134) (-0.00056998866, -0.00013278874) (-0.00057027934, -0.0001330522) (-0.0005705826, -0.00013330107) (-0.0005708977, -0.00013353477) (-0.00057122389, -0.00013375272) (-0.00057156038, -0.00013395441) (-0.00057190636, -0.00013413934) (-0.000572261, -0.00013430707) (-0.00057262344, -0.0001344572) (-0.00057299281, -0.00013458936) (-0.00057336823, -0.00013470324) (-0.00057374877, -0.00013479856) (-0.00057413354, -0.0001348751) (-0.0005745216, -0.00013493266) (-0.00057491201, -0.00013497111) (-0.00057540194, -0.00013499518) (-0.00057559818, -0.000135) (-0.00073240182, -0.000135) (-0.00073259806, -0.00013499518) (-0.00073308798, -0.00013497111) (-0.0007334784, -0.00013493266) (-0.00073386646, -0.0001348751) (-0.00073425123, -0.00013479856) (-0.00073463177, -0.00013470324) (-0.00073500719, -0.00013458936) (-0.00073537656, -0.0001344572) (-0.000735739, -0.00013430707) (-0.00073609364, -0.00013413934) (-0.00073643962, -0.00013395441) (-0.00073677611, -0.00013375272) (-0.0007371023, -0.00013353477) (-0.0007374174, -0.00013330107) (-0.00073772066, -0.0001330522) (-0.00073801134, -0.00013278874) (-0.00073828874, -0.00013251134) (-0.0007385522, -0.00013222066) (-0.00073880107, -0.00013191741) (-0.00073903477, -0.0001316023) (-0.00073925272, -0.00013127611) (-0.00073945441, -0.00013093962) (-0.00073963934, -0.00013059364) (-0.00073980707, -0.000130239) (-0.0007399572, -0.00012987656) (-0.00074008936, -0.00012950719) (-0.00074020324, -0.00012913177) (-0.00074029856, -0.00012875123) (-0.0007403751, -0.00012836646) (-0.00074043266, -0.0001279784) (-0.00074047111, -0.00012758798) (-0.00074049518, -0.00012709806) (-0.0007405, -0.00012690182) (-0.0007405, 0.00012690182) (-0.00074049518, 0.00012709806) (-0.00074047111, 0.00012758798) (-0.00074043266, 0.0001279784) (-0.0007403751, 0.00012836646) (-0.00074029856, 0.00012875123) (-0.00074020324, 0.00012913177) (-0.00074008936, 0.00012950719) (-0.0007399572, 0.00012987656) (-0.00073980707, 0.000130239) (-0.00073963934, 0.00013059364) (-0.00073945441, 0.00013093962) (-0.00073925272, 0.00013127611) (-0.00073903477, 0.0001316023) (-0.00073880107, 0.00013191741) (-0.0007385522, 0.00013222066) (-0.00073828874, 0.00013251134) (-0.00073801134, 0.00013278874) (-0.00073772066, 0.0001330522) (-0.0007374174, 0.00013330107) (-0.0007371023, 0.00013353477) (-0.00073677611, 0.00013375272) (-0.00073643962, 0.00013395441) (-0.00073609364, 0.00013413934) (-0.000735739, 0.00013430707) (-0.00073537656, 0.0001344572) (-0.00073500719, 0.00013458936) (-0.00073463177, 0.00013470324) (-0.00073425123, 0.00013479856) (-0.00073386646, 0.0001348751) (-0.0007334784, 0.00013493266) (-0.00073308798, 0.00013497111) (-0.00073259806, 0.00013499518) (-0.00073240182, 0.000135) (-0.00057559818, 0.000135) (-0.00057540194, 0.00013499518) (-0.00057491201, 0.00013497111) (-0.0005745216, 0.00013493266) (-0.00057413354, 0.0001348751) (-0.00057374877, 0.00013479856) (-0.00057336823, 0.00013470324) (-0.00057299281, 0.00013458936) (-0.00057262344, 0.0001344572) (-0.000572261, 0.00013430707) (-0.00057190636, 0.00013413934) (-0.00057156038, 0.00013395441) (-0.00057122389, 0.00013375272) (-0.0005708977, 0.00013353477) (-0.0005705826, 0.00013330107) (-0.00057027934, 0.0001330522) (-0.00056998866, 0.00013278874) (-0.00056971126, 0.00013251134) (-0.0005694478, 0.00013222066) (-0.00056919893, 0.00013191741) (-0.00056896523, 0.0001316023) (-0.00056874728, 0.00013127611) (-0.00056854559, 0.00013093962) (-0.00056836066, 0.00013059364) (-0.00056819293, 0.000130239) (-0.0005680428, 0.00012987656) (-0.00056791064, 0.00012950719) (-0.00056779676, 0.00012913177) (-0.00056770144, 0.00012875123) (-0.0005676249, 0.00012836646) (-0.00056756734, 0.0001279784) (-0.00056752889, 0.00012758798) (-0.00056750482, 0.00012709806) (-0.0005675, 0.00012690182) (-0.0005675, 1.909818e-05) (-0.00056750482, 1.8901939e-05) (-0.00056752889, 1.8412015e-05) (-0.00056756734, 1.80216e-05) (-0.0005676249, 1.7633541e-05) (-0.00056770144, 1.7248774e-05) (-0.00056779676, 1.6868226e-05) (-0.00056791064, 1.6492814e-05) (-0.0005680428, 1.6123441e-05) (-0.00056819293, 1.5760999e-05) (-0.00056836066, 1.540636e-05) (-0.00056854559, 1.5060378e-05) (-0.00056874728, 1.4723887e-05) (-0.00056896523, 1.4397697e-05) (-0.00056919893, 1.4082595e-05) (-0.0005694478, 1.3779339e-05) (-0.00056971126, 1.348866e-05) (-0.00056998866, 1.3211259e-05) (-0.00057027934, 1.2947803e-05) (-0.0005705826, 1.2698928e-05) (-0.0005708977, 1.2465232e-05) (-0.00057122389, 1.2247279e-05) (-0.00057156038, 1.2045594e-05) (-0.00057190636, 1.1860663e-05) (-0.000572261, 1.1692931e-05) (-0.00057262344, 1.1542802e-05) (-0.00057299281, 1.1410639e-05) (-0.00057336823, 1.1296759e-05) (-0.00057374877, 1.1201436e-05) (-0.00057413354, 1.1124902e-05) (-0.0005745216, 1.1067338e-05) (-0.00057491201, 1.1028886e-05) (-0.00057540194, 1.1004817e-05) (-0.00057559818, 1.1e-05) (-0.00062340182, 1.1e-05) (-0.00062359806, 1.1004817e-05) (-0.00062408799, 1.1028886e-05) (-0.0006244784, 1.1067338e-05) (-0.00062486646, 1.1124902e-05) (-0.00062525123, 1.1201436e-05) (-0.00062563177, 1.1296759e-05) (-0.00062600719, 1.1410639e-05) (-0.00062637656, 1.1542802e-05) (-0.000626739, 1.1692931e-05) (-0.00062709364, 1.1860663e-05) (-0.00062743962, 1.2045594e-05) (-0.00062777611, 1.2247279e-05) (-0.0006281023, 1.2465232e-05) (-0.00062841741, 1.2698928e-05) (-0.00062872066, 1.2947803e-05) (-0.00062901134, 1.3211259e-05) (-0.00062928874, 1.348866e-05) (-0.0006295522, 1.3779339e-05) (-0.00062980107, 1.4082595e-05) (-0.00063003477, 1.4397697e-05) (-0.00063025272, 1.4723887e-05) (-0.00063045441, 1.5060378e-05) (-0.00063063934, 1.540636e-05) (-0.00063080707, 1.5760999e-05) (-0.0006309572, 1.6123441e-05) (-0.00063108936, 1.6492814e-05) (-0.00063120324, 1.6868226e-05)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, closed, covered)
  pocket_cin = polyline(z=0, xy: (-0.0007525, -0.000135) (-0.0007525, 0.000135) (-0.00075244222, 0.00013617621) (-0.00075226942, 0.00013734108) (-0.00075198328, 0.00013848342) (-0.00075158655, 0.0001395922) (-0.00075108306, 0.00014065676) (-0.00075047764, 0.00014166684) (-0.00074977613, 0.00014261272) (-0.00074898528, 0.00014348528) (-0.00074811272, 0.00014427613) (-0.00074716684, 0.00014497764) (-0.00074615676, 0.00014558305) (-0.0007450922, 0.00014608655) (-0.00074398342, 0.00014648328) (-0.00074284108, 0.00014676942) (-0.00074167621, 0.00014694222) (-0.0007405, 0.000147) (-0.0005675, 0.000147) (-0.00056632379, 0.00014694222) (-0.00056515892, 0.00014676942) (-0.00056401658, 0.00014648328) (-0.0005629078, 0.00014608655) (-0.00056184324, 0.00014558305) (-0.00056083316, 0.00014497764) (-0.00055988728, 0.00014427613) (-0.00055901472, 0.00014348528) (-0.00055822388, 0.00014261272) (-0.00055752237, 0.00014166684) (-0.00055691694, 0.00014065676) (-0.00055641345, 0.0001395922) (-0.00055601672, 0.00013848342) (-0.00055573058, 0.00013734108) (-0.00055555778, 0.00013617621) (-0.0005555, 0.000135) (-0.0005555, -0.000135) (-0.00055555778, -0.00013617621) (-0.00055573058, -0.00013734108) (-0.00055601672, -0.00013848342) (-0.00055641345, -0.0001395922) (-0.00055691694, -0.00014065676) (-0.00055752237, -0.00014166684) (-0.00055822388, -0.00014261272) (-0.00055901472, -0.00014348528) (-0.00055988728, -0.00014427613) (-0.00056083316, -0.00014497764) (-0.00056184324, -0.00014558305) (-0.0005629078, -0.00014608655) (-0.00056401658, -0.00014648328) (-0.00056515892, -0.00014676942) (-0.00056632379, -0.00014694222) (-0.0005675, -0.000147) (-0.0007405, -0.000147) (-0.00074167621, -0.00014694222) (-0.00074284108, -0.00014676942) (-0.00074398342, -0.00014648328) (-0.0007450922, -0.00014608655) (-0.00074615676, -0.00014558305) (-0.00074716684, -0.00014497764) (-0.00074811272, -0.00014427613) (-0.00074898528, -0.00014348528) (-0.00074977613, -0.00014261272) (-0.00075047764, -0.00014166684) (-0.00075108306, -0.00014065676) (-0.00075158655, -0.0001395922) (-0.00075198328, -0.00013848342) (-0.00075226942, -0.00013734108) (-0.00075244222, -0.00013617621) (-0.0007525, -0.000135), closed, covered)
  tap_trace_n0 = polyline(z=0, xy: (0.00015, -5e-06) (-0.00015, -5e-06) (-0.00015, 5e-06) (-5e-06, 5e-06) (-5e-06, 0.0001) (5e-06, 0.0001) (5e-06, 5e-06) (0.00015, 5e-06) (0.00015, -5e-06), closed, covered)
  tap_cut_n0 = polyline(z=0, xy: (0.00015, -1.1e-05) (-0.00015, -1.1e-05) (-0.00015, 1.1e-05) (-1.1e-05, 1.1e-05) (-1.1e-05, 0.0001) (1.1e-05, 0.0001) (1.1e-05, 1.1e-05) (0.00015, 1.1e-05) (0.00015, -1.1e-05), closed, covered)
  plate_cp = polyline(z=0, xy: (7e-05, 0.00027) (6.9961478e-05, 0.00026921586) (6.9846282e-05, 0.00026843928) (6.9655523e-05, 0.00026767772) (6.9391036e-05, 0.00026693853) (6.905537e-05, 0.00026622883) (6.8651757e-05, 0.00026555544) (6.8184084e-05, 0.00026492485) (6.7656854e-05, 0.00026434315) (6.7075146e-05, 0.00026381592) (6.6444562e-05, 0.00026334824) (6.5771174e-05, 0.00026294463) (6.5061467e-05, 0.00026260896) (6.4322277e-05, 0.00026234448) (6.3560723e-05, 0.00026215372) (6.2784137e-05, 0.00026203852) (6.2e-05, 0.000262) (-6.2e-05, 0.000262) (-6.2784137e-05, 0.00026203852) (-6.3560723e-05, 0.00026215372) (-6.4322277e-05, 0.00026234448) (-6.5061467e-05, 0.00026260896) (-6.5771174e-05, 0.00026294463) (-6.6444562e-05, 0.00026334824) (-6.7075146e-05, 0.00026381592) (-6.7656854e-05, 0.00026434315) (-6.8184084e-05, 0.00026492485) (-6.8651757e-05, 0.00026555544) (-6.905537e-05, 0.00026622883) (-6.9391036e-05, 0.00026693853) (-6.9655523e-05, 0.00026767772) (-6.9846282e-05, 0.00026843928) (-6.9961478e-05, 0.00026921586) (-7e-05, 0.00027) (-7e-05, 0.000295) (-6.9961478e-05, 0.00029578414) (-6.9846282e-05, 0.00029656072) (-6.9655523e-05, 0.00029732228) (-6.9391036e-05, 0.00029806147) (-6.905537e-05, 0.00029877117) (-6.8651757e-05, 0.00029944456) (-6.8184084e-05, 0.00030007515) (-6.7656854e-05, 0.00030065685) (-6.7075146e-05, 0.00030118408) (-6.6444562e-05, 0.00030165176) (-6.5771174e-05, 0.00030205537) (-6.5061467e-05, 0.00030239104) (-6.4322277e-05, 0.00030265552) (-6.3560723e-05, 0.00030284628) (-6.2784137e-05, 0.00030296148) (-6.2e-05, 0.000303) (6.2e-05, 0.000303) (6.2784137e-05, 0.00030296148) (6.3560723e-05, 0.00030284628) (6.4322277e-05, 0.00030265552) (6.5061467e-05, 0.00030239104) (6.5771174e-05, 0.00030205537) (6.6444562e-05, 0.00030165176) (6.7075146e-05, 0.00030118408) (6.7656854e-05, 0.00030065685) (6.8184084e-05, 0.00030007515) (6.8651757e-05, 0.00029944456) (6.905537e-05, 0.00029877117) (6.9391036e-05, 0.00029806147) (6.9655523e-05, 0.00029732228) (6.9846282e-05, 0.00029656072) (6.9961478e-05, 0.00029578414) (7e-05, 0.000295) (7e-05, 0.00027), closed, covered)
  frame_cp = polyline(z=0, xy: (7e-05, 0.000254) (7.0784137e-05, 0.00025403852) (7.1560723e-05, 0.00025415372) (7.2322277e-05, 0.00025434448) (7.3061467e-05, 0.00025460896) (7.3771174e-05, 0.00025494463) (7.4444562e-05, 0.00025534824) (7.5075146e-05, 0.00025581592) (7.5656854e-05, 0.00025634315) (7.6184084e-05, 0.00025692485) (7.6651757e-05, 0.00025755544) (7.705537e-05, 0.00025822883) (7.7391036e-05, 0.00025893853) (7.7655523e-05, 0.00025967772) (7.7846282e-05, 0.00026043928) (7.7961478e-05, 0.00026121586) (7.8e-05, 0.000262) (7.8e-05, 0.000303) (7.7961478e-05, 0.00030378414) (7.7846282e-05, 0.00030456072) (7.7655523e-05, 0.00030532228) (7.7391036e-05, 0.00030606147) (7.705537e-05, 0.00030677117) (7.6651757e-05, 0.00030744456) (7.6184084e-05, 0.00030807515) (7.5656854e-05, 0.00030865685) (7.5075146e-05, 0.00030918408) (7.4444562e-05, 0.00030965176) (7.3771174e-05, 0.00031005537) (7.3061467e-05, 0.00031039104) (7.2322277e-05, 0.00031065552) (7.1560723e-05, 0.00031084628) (7.0784137e-05, 0.00031096148) (7e-05, 0.000311) (1.909818e-05, 0.000311) (1.8901939e-05, 0.00031100482) (1.8412015e-05, 0.00031102889) (1.80216e-05, 0.00031106734) (1.7633541e-05, 0.0003111249) (1.7248774e-05, 0.00031120144) (1.6868226e-05, 0.00031129676) (1.6492814e-05, 0.00031141064) (1.6123441e-05, 0.0003115428) (1.5760999e-05, 0.00031169293) (1.540636e-05, 0.00031186066) (1.5060378e-05, 0.00031204559) (1.4723887e-05, 0.00031224728) (1.4397697e-05, 0.00031246523) (1.4082595e-05, 0.00031269893) (1.3779339e-05, 0.0003129478) (1.348866e-05, 0.00031321126) (1.3211259e-05, 0.00031348866) (1.2947803e-05, 0.00031377934) (1.2698928e-05, 0.00031408259) (1.2465232e-05, 0.0003143977) (1.2247279e-05, 0.00031472389) (1.2045594e-05, 0.00031506038) (1.1860663e-05, 0.00031540636) (1.1692931e-05, 0.000315761) (1.1542802e-05, 0.00031612344) (1.1410639e-05, 0.00031649281) (1.1296759e-05, 0.00031686823) (1.1201436e-05, 0.00031724877) (1.1124902e-05, 0.00031763354) (1.1067338e-05, 0.0003180216) (1.1028886e-05, 0.00031841202) (1.1004817e-05, 0.00031890194) (1.1e-05, 0.00031909818) (1.1e-05, 0.00036690182) (1.1004817e-05, 0.00036709806) (1.1028886e-05, 0.00036758799) (1.1067338e-05, 0.0003679784) (1.1124902e-05, 0.00036836646) (1.1201436e-05, 0.00036875123) (1.1296759e-05, 0.00036913177) (1.1410639e-05, 0.00036950719) (1.1542802e-05, 0.00036987656) (1.1692931e-05, 0.000370239) (1.1860663e-05, 0.00037059364) (1.2045594e-05, 0.00037093962) (1.2247279e-05, 0.00037127611) (1.2465232e-05, 0.0003716023) (1.2698928e-05, 0.0003719174) (1.2947803e-05, 0.00037222066) (1.3211259e-05, 0.00037251134) (1.348866e-05, 0.00037278874) (1.3779339e-05, 0.0003730522) (1.4082595e-05, 0.00037330107) (1.4397697e-05, 0.00037353477) (1.4723887e-05, 0.00037375272) (1.5060378e-05, 0.00037395441) (1.540636e-05, 0.00037413934) (1.5760999e-05, 0.00037430707) (1.6123441e-05, 0.0003744572) (1.6492814e-05, 0.00037458936) (1.6868226e-05, 0.00037470324) (1.7248774e-05, 0.00037479856) (1.7633541e-05, 0.0003748751) (1.80216e-05, 0.00037493266) (1.8412015e-05, 0.00037497111) (1.8901939e-05, 0.00037499518) (1.909818e-05, 0.000375) (0.00012690182, 0.000375) (0.00012709806, 0.00037499518) (0.00012758798, 0.00037497111) (0.0001279784, 0.00037493266) (0.00012836646, 0.0003748751) (0.00012875123, 0.00037479856) (0.00012913177, 0.00037470324) (0.00012950719, 0.00037458936) (0.00012987656, 0.0003744572) (0.000130239, 0.00037430707) (0.00013059364, 0.00037413934) (0.00013093962, 0.00037395441) (0.00013127611, 0.00037375272) (0.0001316023, 0.00037353477) (0.00013191741, 0.00037330107) (0.00013222066, 0.0003730522) (0.00013251134, 0.00037278874) (0.00013278874, 0.00037251134) (0.0001330522, 0.00037222066) (0.00013330107, 0.0003719174) (0.00013353477, 0.0003716023) (0.00013375272, 0.00037127611) (0.00013395441, 0.00037093962) (0.00013413934, 0.00037059364) (0.00013430707, 0.000370239) (0.0001344572, 0.00036987656) (0.00013458936, 0.00036950719) (0.00013470324, 0.00036913177) (0.00013479856, 0.00036875123) (0.0001348751, 0.00036836646) (0.00013493266, 0.0003679784) (0.00013497111, 0.00036758799) (0.00013499518, 0.00036709806) (0.000135, 0.00036690182) (0.000135, 0.00021009818) (0.00013499518, 0.00020990194) (0.00013497111, 0.00020941201) (0.00013493266, 0.0002090216) (0.0001348751, 0.00020863354) (0.00013479856, 0.00020824877) (0.00013470324, 0.00020786823) (0.00013458936, 0.00020749281) (0.0001344572, 0.00020712344) (0.00013430707, 0.000206761) (0.00013413934, 0.00020640636) (0.00013395441, 0.00020606038) (0.00013375272, 0.00020572389) (0.00013353477, 0.0002053977) (0.00013330107, 0.00020508259) (0.0001330522, 0.00020477934) (0.00013278874, 0.00020448866) (0.00013251134, 0.00020421126) (0.00013222066, 0.0002039478) (0.00013191741, 0.00020369893) (0.0001316023, 0.00020346523) (0.00013127611, 0.00020324728) (0.00013093962, 0.00020304559) (0.00013059364, 0.00020286066) (0.000130239, 0.00020269293) (0.00012987656, 0.0002025428) (0.00012950719, 0.00020241064) (0.00012913177, 0.00020229676) (0.00012875123, 0.00020220144) (0.00012836646, 0.0002021249) (0.0001279784, 0.00020206734) (0.00012758798, 0.00020202889) (0.00012709806, 0.00020200482) (0.00012690182, 0.000202) (-0.00012690182, 0.000202) (-0.00012709806, 0.00020200482) (-0.00012758798, 0.00020202889) (-0.0001279784, 0.00020206734) (-0.00012836646, 0.0002021249) (-0.00012875123, 0.00020220144) (-0.00012913177, 0.00020229676) (-0.00012950719, 0.00020241064) (-0.00012987656, 0.0002025428) (-0.000130239, 0.00020269293) (-0.00013059364, 0.00020286066) (-0.00013093962, 0.00020304559) (-0.00013127611, 0.00020324728) (-0.0001316023, 0.00020346523) (-0.00013191741, 0.00020369893) (-0.00013222066, 0.0002039478) (-0.00013251134, 0.00020421126) (-0.00013278874, 0.00020448866) (-0.0001330522, 0.00020477934) (-0.00013330107, 0.00020508259) (-0.00013353477, 0.0002053977) (-0.00013375272, 0.00020572389) (-0.00013395441, 0.00020606038) (-0.00013413934, 0.00020640636) (-0.00013430707, 0.000206761) (-0.0001344572, 0.00020712344) (-0.00013458936, 0.00020749281) (-0.00013470324, 0.00020786823) (-0.00013479856, 0.00020824877) (-0.0001348751, 0.00020863354) (-0.00013493266, 0.0002090216) (-0.00013497111, 0.00020941201) (-0.00013499518, 0.00020990194) (-0.000135, 0.00021009818) (-0.000135, 0.00036690182) (-0.00013499518, 0.00036709806) (-0.00013497111, 0.00036758799) (-0.00013493266, 0.0003679784) (-0.0001348751, 0.00036836646) (-0.00013479856, 0.00036875123) (-0.00013470324, 0.00036913177) (-0.00013458936, 0.00036950719) (-0.0001344572, 0.00036987656) (-0.00013430707, 0.000370239) (-0.00013413934, 0.00037059364) (-0.00013395441, 0.00037093962) (-0.00013375272, 0.00037127611) (-0.00013353477, 0.0003716023) (-0.00013330107, 0.0003719174) (-0.0001330522, 0.00037222066) (-0.00013278874, 0.00037251134) (-0.00013251134, 0.00037278874) (-0.00013222066, 0.0003730522) (-0.00013191741, 0.00037330107) (-0.0001316023, 0.00037353477) (-0.00013127611, 0.00037375272) (-0.00013093962, 0.00037395441) (-0.00013059364, 0.00037413934) (-0.000130239, 0.00037430707) (-0.00012987656, 0.0003744572) (-0.00012950719, 0.00037458936) (-0.00012913177, 0.00037470324) (-0.00012875123, 0.00037479856) (-0.00012836646, 0.0003748751) (-0.0001279784, 0.00037493266) (-0.00012758798, 0.00037497111) (-0.00012709806, 0.00037499518) (-0.00012690182, 0.000375) (-1.909818e-05, 0.000375) (-1.8901939e-05, 0.00037499518) (-1.8412015e-05, 0.00037497111) (-1.80216e-05, 0.00037493266) (-1.7633541e-05, 0.0003748751) (-1.7248774e-05, 0.00037479856) (-1.6868226e-05, 0.00037470324) (-1.6492814e-05, 0.00037458936) (-1.6123441e-05, 0.0003744572) (-1.5760999e-05, 0.00037430707) (-1.540636e-05, 0.00037413934) (-1.5060378e-05, 0.00037395441) (-1.4723887e-05, 0.00037375272) (-1.4397697e-05, 0.00037353477) (-1.4082595e-05, 0.00037330107) (-1.3779339e-05, 0.0003730522) (-1.348866e-05, 0.00037278874) (-1.3211259e-05, 0.00037251134) (-1.2947803e-05, 0.00037222066) (-1.2698928e-05, 0.0003719174) (-1.2465232e-05, 0.0003716023) (-1.2247279e-05, 0.00037127611) (-1.2045594e-05, 0.00037093962) (-1.1860663e-05, 0.00037059364) (-1.1692931e-05, 0.000370239) (-1.1542802e-05, 0.00036987656) (-1.1410639e-05, 0.00036950719) (-1.1296759e-05, 0.00036913177) (-1.1201436e-05, 0.00036875123) (-1.1124902e-05, 0.00036836646) (-1.1067338e-05, 0.0003679784) (-1.1028886e-05, 0.00036758799) (-1.1004817e-05, 0.00036709806) (-1.1e-05, 0.00036690182) (-1.1e-05, 0.00031909818) (-1.1004817e-05, 0.00031890194) (-1.1028886e-05, 0.00031841202) (-1.1067338e-05, 0.0003180216) (-1.1124902e-05, 0.00031763354) (-1.1201436e-05, 0.00031724877) (-1.1296759e-05, 0.00031686823) (-1.1410639e-05, 0.00031649281) (-1.1542802e-05, 0.00031612344) (-1.1692931e-05, 0.000315761) (-1.1860663e-05, 0.00031540636) (-1.2045594e-05, 0.00031506038) (-1.2247279e-05, 0.00031472389) (-1.2465232e-05, 0.0003143977) (-1.2698928e-05, 0.00031408259) (-1.2947803e-05, 0.00031377934) (-1.3211259e-05, 0.00031348866) (-1.348866e-05, 0.00031321126) (-1.3779339e-05, 0.0003129478) (-1.4082595e-05, 0.00031269893) (-1.4397697e-05, 0.00031246523) (-1.4723887e-05, 0.00031224728) (-1.5060378e-05, 0.00031204559) (-1.540636e-05, 0.00031186066) (-1.5760999e-05, 0.00031169293) (-1.6123441e-05, 0.0003115428) (-1.6492814e-05, 0.00031141064) (-1.6868226e-05, 0.00031129676)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, closed, covered)
  pocket_cp = polyline(z=0, xy: (0.000135, 0.00019) (-0.000135, 0.00019) (-0.00013617621, 0.00019005778) (-0.00013734108, 0.00019023058) (-0.00013848342, 0.00019051672) (-0.0001395922, 0.00019091345) (-0.00014065676, 0.00019141694) (-0.00014166684, 0.00019202237) (-0.00014261272, 0.00019272388) (-0.00014348528, 0.00019351472) (-0.00014427613, 0.00019438728) (-0.00014497764, 0.00019533316) (-0.00014558305, 0.00019634324) (-0.00014608655, 0.0001974078) (-0.00014648328, 0.00019851658) (-0.00014676942, 0.00019965892) (-0.00014694222, 0.00020082379) (-0.000147, 0.000202) (-0.000147, 0.000375) (-0.00014694222, 0.00037617621) (-0.00014676942, 0.00037734108) (-0.00014648328, 0.00037848342) (-0.00014608655, 0.0003795922) (-0.00014558305, 0.00038065676) (-0.00014497764, 0.00038166684) (-0.00014427613, 0.00038261272) (-0.00014348528, 0.00038348528) (-0.00014261272, 0.00038427613) (-0.00014166684, 0.00038497764) (-0.00014065676, 0.00038558305) (-0.0001395922, 0.00038608655) (-0.00013848342, 0.00038648328) (-0.00013734108, 0.00038676942) (-0.00013617621, 0.00038694222) (-0.000135, 0.000387) (0.000135, 0.000387) (0.00013617621, 0.00038694222) (0.00013734108, 0.00038676942) (0.00013848342, 0.00038648328) (0.0001395922, 0.00038608655) (0.00014065676, 0.00038558305) (0.00014166684, 0.00038497764) (0.00014261272, 0.00038427613) (0.00014348528, 0.00038348528) (0.00014427613, 0.00038261272) (0.00014497764, 0.00038166684) (0.00014558305, 0.00038065676) (0.00014608655, 0.0003795922) (0.00014648328, 0.00037848342) (0.00014676942, 0.00037734108) (0.00014694222, 0.00037617621) (0.000147, 0.000375) (0.000147, 0.000202) (0.00014694222, 0.00020082379) (0.00014676942, 0.00019965892) (0.00014648328, 0.00019851658) (0.00014608655, 0.0001974078) (0.00014558305, 0.00019634324) (0.00014497764, 0.00019533316) (0.00014427613, 0.00019438728) (0.00014348528, 0.00019351472) (0.00014261272, 0.00019272388) (0.00014166684, 0.00019202237) (0.00014065676, 0.00019141694) (0.0001395922, 0.00019091345) (0.00013848342, 0.00019051672) (0.00013734108, 0.00019023058) (0.00013617621, 0.00019005778) (0.000135, 0.00019), closed, covered)
  tap_trace_jf = polyline(z=0, xy: (-5e-06, 0.001465) (-5e-06, 0.001765) (5e-06, 0.001765) (5e-06, 0.00162) (7.55e-05, 0.00162) (7.55e-05, 0.00161) (5e-06, 0.00161) (5e-06, 0.001465) (-5e-06, 0.001465), closed, covered)
  tap_cut_jf = polyline(z=0, xy: (-1.1e-05, 0.001465) (-1.1e-05, 0.001765) (1.1e-05, 0.001765) (1.1e-05, 0.001626) (7.55e-05, 0.001626) (7.55e-05, 0.001604) (1.1e-05, 0.001604) (1.1e-05, 0.001465) (-1.1e-05, 0.001465), closed, covered)
  tap_trace_jr = polyline(z=0, xy: (0.0001745, 0.00162) (0.000245, 0.00162) (0.000245, 0.001765) (0.000255, 0.001765) (0.000255, 0.001465) (0.000245, 0.001465) (0.000245, 0.00161) (0.0001745, 0.00161) (0.0001745, 0.00162), closed, covered)
  tap_cut_jr = polyline(z=0, xy: (0.0001745, 0.001626) (0.000239, 0.001626) (0.000239, 0.001765) (0.000261, 0.001765) (0.000261, 0.001465) (0.000239, 0.001465) (0.000239, 0.001604) (0.0001745, 0.001604) (0.0001745, 0.001626), closed, covered)
  head_a_cj = polyline(z=0, xy: (0.0001075, 0.001596) (0.00010730397, 0.0015960096) (0.00010710982, 0.0015960384) (0.00010691943, 0.0015960861) (0.00010673463, 0.0015961522) (0.00010655721, 0.0015962362) (0.00010638886, 0.0015963371) (0.00010623121, 0.001596454) (0.00010608579, 0.0015965858) (0.00010595398, 0.0015967312) (0.00010583706, 0.0015968889) (0.00010573616, 0.0015970572) (0.00010565224, 0.0015972346) (0.00010558612, 0.0015974194) (0.00010553843, 0.0015976098) (0.00010550963, 0.001597804) (0.0001055, 0.001598) (0.0001055, 0.001632) (0.00010550963, 0.001632196) (0.00010553843, 0.0016323902) (0.00010558612, 0.0016325806) (0.00010565224, 0.0016327654) (0.00010573616, 0.0016329428) (0.00010583706, 0.0016331111) (0.00010595398, 0.0016332688) (0.00010608579, 0.0016334142) (0.00010623121, 0.001633546) (0.00010638886, 0.0016336629) (0.00010655721, 0.0016337638) (0.00010673463, 0.0016338478) (0.00010691943, 0.0016339139) (0.00010710982, 0.0016339616) (0.00010730397, 0.0016339904) (0.0001075, 0.001634) (0.0001185, 0.001634) (0.00011869603, 0.0016339904) (0.00011889018, 0.0016339616) (0.00011908057, 0.0016339139) (0.00011926537, 0.0016338478) (0.00011944279, 0.0016337638) (0.00011961114, 0.0016336629) (0.00011976879, 0.001633546) (0.00011991421, 0.0016334142) (0.00012004602, 0.0016332688) (0.00012016294, 0.0016331111) (0.00012026384, 0.0016329428) (0.00012034776, 0.0016327654) (0.00012041388, 0.0016325806) (0.00012046157, 0.0016323902) (0.00012049037, 0.001632196) (0.0001205, 0.001632) (0.0001205, 0.001598) (0.00012049037, 0.001597804) (0.00012046157, 0.0015976098) (0.00012041388, 0.0015974194) (0.00012034776, 0.0015972346) (0.00012026384, 0.0015970572) (0.00012016294, 0.0015968889) (0.00012004602, 0.0015967312) (0.00011991421, 0.0015965858) (0.00011976879, 0.001596454) (0.00011961114, 0.0015963371) (0.00011944279, 0.0015962362) (0.00011926537, 0.0015961522) (0.00011908057, 0.0015960861) (0.00011889018, 0.0015960384) (0.00011869603, 0.0015960096) (0.0001185, 0.001596) (0.0001075, 0.001596), closed, covered)
  head_b_cj = polyline(z=0, xy: (0.0001315, 0.001596) (0.00013130397, 0.0015960096) (0.00013110982, 0.0015960384) (0.00013091943, 0.0015960861) (0.00013073463, 0.0015961522) (0.00013055721, 0.0015962362) (0.00013038886, 0.0015963371) (0.00013023121, 0.001596454) (0.00013008579, 0.0015965858) (0.00012995398, 0.0015967312) (0.00012983706, 0.0015968889) (0.00012973616, 0.0015970572) (0.00012965224, 0.0015972346) (0.00012958612, 0.0015974194) (0.00012953843, 0.0015976098) (0.00012950963, 0.001597804) (0.0001295, 0.001598) (0.0001295, 0.001632) (0.00012950963, 0.001632196) (0.00012953843, 0.0016323902) (0.00012958612, 0.0016325806) (0.00012965224, 0.0016327654) (0.00012973616, 0.0016329428) (0.00012983706, 0.0016331111) (0.00012995398, 0.0016332688) (0.00013008579, 0.0016334142) (0.00013023121, 0.001633546) (0.00013038886, 0.0016336629) (0.00013055721, 0.0016337638) (0.00013073463, 0.0016338478) (0.00013091943, 0.0016339139) (0.00013110982, 0.0016339616) (0.00013130397, 0.0016339904) (0.0001315, 0.001634) (0.0001425, 0.001634) (0.00014269603, 0.0016339904) (0.00014289018, 0.0016339616) (0.00014308057, 0.0016339139) (0.00014326537, 0.0016338478) (0.00014344279, 0.0016337638) (0.00014361114, 0.0016336629) (0.00014376879, 0.001633546) (0.00014391421, 0.0016334142) (0.00014404602, 0.0016332688) (0.00014416294, 0.0016331111) (0.00014426384, 0.0016329428) (0.00014434776, 0.0016327654) (0.00014441388, 0.0016325806) (0.00014446157, 0.0016323902) (0.00014449037, 0.001632196) (0.0001445, 0.001632) (0.0001445, 0.001598) (0.00014449037, 0.001597804) (0.00014446157, 0.0015976098) (0.00014441388, 0.0015974194) (0.00014434776, 0.0015972346) (0.00014426384, 0.0015970572) (0.00014416294, 0.0015968889) (0.00014404602, 0.0015967312) (0.00014391421, 0.0015965858) (0.00014376879, 0.001596454) (0.00014361114, 0.0015963371) (0.00014344279, 0.0015962362) (0.00014326537, 0.0015961522) (0.00014308057, 0.0015960861) (0.00014289018, 0.0015960384) (0.00014269603, 0.0015960096) (0.0001425, 0.001596) (0.0001315, 0.001596), closed, covered)
  pocket_cj = polyline(z=0, xy: (9.75e-05, 0.001586) (9.7303966e-05, 0.0015860096) (9.7109819e-05, 0.0015860384) (9.6919431e-05, 0.0015860861) (9.6734633e-05, 0.0015861522) (9.6557207e-05, 0.0015862362) (9.638886e-05, 0.0015863371) (9.6231213e-05, 0.001586454) (9.6085786e-05, 0.0015865858) (9.5953979e-05, 0.0015867312) (9.5837061e-05, 0.0015868889) (9.5736157e-05, 0.0015870572) (9.5652241e-05, 0.0015872346) (9.5586119e-05, 0.0015874194) (9.5538429e-05, 0.0015876098) (9.5509631e-05, 0.001587804) (9.55e-05, 0.001588) (9.55e-05, 0.001642) (9.5509631e-05, 0.001642196) (9.5538429e-05, 0.0016423902) (9.5586119e-05, 0.0016425806) (9.5652241e-05, 0.0016427654) (9.5736157e-05, 0.0016429428) (9.5837061e-05, 0.0016431111) (9.5953979e-05, 0.0016432688) (9.6085786e-05, 0.0016434142) (9.6231213e-05, 0.001643546) (9.638886e-05, 0.0016436629) (9.6557207e-05, 0.0016437638) (9.6734633e-05, 0.0016438478) (9.6919431e-05, 0.0016439139) (9.7109819e-05, 0.0016439616) (9.7303966e-05, 0.0016439904) (9.75e-05, 0.001644) (0.0001525, 0.001644) (0.00015269603, 0.0016439904) (0.00015289018, 0.0016439616) (0.00015308057, 0.0016439139) (0.00015326537, 0.0016438478) (0.00015344279, 0.0016437638) (0.00015361114, 0.0016436629) (0.00015376879, 0.001643546) (0.00015391421, 0.0016434142) (0.00015404602, 0.0016432688) (0.00015416294, 0.0016431111) (0.00015426384, 0.0016429428) (0.00015434776, 0.0016427654) (0.00015441388, 0.0016425806) (0.00015446157, 0.0016423902) (0.00015449037, 0.001642196) (0.0001545, 0.001642) (0.0001545, 0.001588) (0.00015449037, 0.001587804) (0.00015446157, 0.0015876098) (0.00015441388, 0.0015874194) (0.00015434776, 0.0015872346) (0.00015426384, 0.0015870572) (0.00015416294, 0.0015868889) (0.00015404602, 0.0015867312) (0.00015391421, 0.0015865858) (0.00015376879, 0.001586454) (0.00015361114, 0.0015863371) (0.00015344279, 0.0015862362) (0.00015326537, 0.0015861522) (0.00015308057, 0.0015860861) (0.00015289018, 0.0015860384) (0.00015269603, 0.0015860096) (0.0001525, 0.001586) (9.75e-05, 0.001586), closed, covered)
  open_to_ground_readout_open = rectangle(corner=(0.000239, 0.002915, 0), x_size=2.2e-05, y_size=6e-06)
  endcap_feed_in_start = rectangle(corner=(-0.001626, -1.1e-05, 0), x_size=6e-06, y_size=2.2e-05)
  endcap_feed_out_end = rectangle(corner=(0.00162, -1.1e-05, 0), x_size=6e-06, y_size=2.2e-05)
  ground_main_plane = rectangle(corner=(-0.00182, -0.000347, 0), x_size=0.00364, y_size=0.003468)
  main [silicon_eps11p45] = box(corner=(-0.00182, -0.000347, -0.0005), size=(0.00364, 0.003468, 0.0005))
  sample_holder [vacuum] = box(corner=(-0.00182, -0.000347, -0.00165), size=(0.00364, 0.003468, 0.00254))
  ground_main_plane.subtract(cut_stub_p, pocket_cp, cut_feed_in, lead_a_sub_cp, open_to_ground_readout_open, cut_res_open_run, cut_feed_jf, endcap_feed_out_end, cut_filter_tail, cut_stub_r, lead_b_sub_cin, lead_a_sub_cin, cut_feed_out, tap_cut_jf, tap_cut_n0, pocket_cj, pocket_cin, cut_stub_f, cut_feed_mid, tap_cut_jr, cut_res_tail, endcap_feed_in_start, lead_b_sub_cp, lead_a_sub_cj, lead_b_sub_cj)
  Port_feed_in_start = rectangle(corner=(-0.001626, -5e-06, 0), x_size=6e-06, y_size=1e-05)
  voltage_line_Port_feed_in_start = polyline((-0.00162, 0, 0) (-0.001626, 0, 0))
  Port_feed_out_end = rectangle(corner=(0.00162, -5e-06, 0), x_size=6e-06, y_size=1e-05)
  voltage_line_Port_feed_out_end = polyline((0.00162, 0, 0) (0.001626, 0, 0))
  g_wb [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=5.325e-05 YPadPos=0.001585 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_1 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00019675 YPadPos=0.001585 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_2 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-3.05e-05 YPadPos=3e-05 ZPadPos=0 XDir=0 YDir=-1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_3 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=3.05e-05 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_4 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=3e-05 YPadPos=6.45e-05 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_5 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.0007664995 YPadPos=3e-05 ZPadPos=0 XDir=0 YDir=-1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_6 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-3e-05 YPadPos=0.0001760005 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_7 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.0014940625 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_8 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.0013021875 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_9 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.0011103125 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_10 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.0009184375 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_11 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000418125 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_12 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000259375 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_13 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000268125 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_14 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000444375 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_15 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000620625 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_16 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000796875 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_17 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000973125 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_18 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.001149375 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_19 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.001325625 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_20 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.001501875 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_21 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=3e-05 YPadPos=0.000125 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_22 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=8.55e-05 YPadPos=0.001585 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_23 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.0001645 YPadPos=0.001585 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_24 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=3e-05 YPadPos=0.000544 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_25 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=3e-05 YPadPos=0.000742 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_26 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=3e-05 YPadPos=0.00094 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_27 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=3e-05 YPadPos=0.001138 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_28 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=3e-05 YPadPos=0.001336 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_29 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00028 YPadPos=0.0018858333 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_30 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00028 YPadPos=0.0020675 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_31 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00028 YPadPos=0.0022491667 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_32 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00028 YPadPos=0.0024308333 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_33 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00028 YPadPos=0.0026125 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_34 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00028 YPadPos=0.0027941667 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_35 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=3e-05 YPadPos=0.00189275 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_36 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=3e-05 YPadPos=0.00208825 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_37 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00017930847 YPadPos=0.002315 ZPadPos=0 XDir=0 YDir=-1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_38 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.0003399254 YPadPos=0.002315 ZPadPos=0 XDir=0 YDir=-1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_39 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00054923387 YPadPos=0.00217 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_40 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00038461694 YPadPos=0.002025 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_41 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00028 YPadPos=0.00194 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_42 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00038461694 YPadPos=0.001855 ZPadPos=0 XDir=0 YDir=-1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_43 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00054923387 YPadPos=0.00171 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_44 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00038461694 YPadPos=0.001565 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_45 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00028 YPadPos=0.00148 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_46 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00038461694 YPadPos=0.001395 ZPadPos=0 XDir=0 YDir=-1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_47 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00054923387 YPadPos=0.0012155 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_48 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00022 YPadPos=0.0013398333 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_49 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00022 YPadPos=0.0011495 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_50 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00022 YPadPos=0.00095916667 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_51 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00043104423 YPadPos=0.000735 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_52 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.0005951327 YPadPos=0.000735 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_53 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00080617693 YPadPos=0.00088 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_54 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00063808846 YPadPos=0.001025 ZPadPos=0 XDir=0 YDir=-1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_55 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00053 YPadPos=0.00111 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_56 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00063808846 YPadPos=0.001195 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_57 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00080617693 YPadPos=0.00134 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_58 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00063808846 YPadPos=0.001485 ZPadPos=0 XDir=0 YDir=-1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_59 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00053 YPadPos=0.00157 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_60 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00063808846 YPadPos=0.001655 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_61 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00080617693 YPadPos=0.0018495 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
boundaries and excitations:
  RLCBoundary_feed_in_start: Lumped RLC Objects=Port_feed_in_start CurrentLine{middle of Port_feed_in_start.edge(x at corner) -> middle of Port_feed_in_start.edge(x opposite corner)} RLC_Type=Parallel Resistance=50ohm
  RLCBoundary_feed_out_end: Lumped RLC Objects=Port_feed_out_end CurrentLine{middle of Port_feed_out_end.edge(x at corner) -> middle of Port_feed_out_end.edge(x opposite corner)} RLC_Type=Parallel Resistance=50ohm
  PerfE: Perfect E Objects=[lead_a_cin, lead_b_cin, lead_a_cp, lead_b_cp, trace_feed_in, trace_feed_mid, trace_feed_out, trace_stub_p, lead_a_cj, lead_b_cj, trace_stub_f, trace_stub_r, trace_feed_jf, trace_res_open_run, trace_filter_tail, trace_res_tail, plate_cin, frame_cin, tap_trace_n0, plate_cp, frame_cp, tap_trace_jf, tap_trace_jr, head_a_cj, head_b_cj, ground_main_plane]
mesh:
  port_mesh: LengthBased Objects=[Port_feed_in_start, Port_feed_out_end] MaxLength=7um
  cpw_line_mesh: LengthBased Objects=[lead_a_cin, lead_b_cin, trace_feed_in, trace_feed_mid, trace_feed_out, trace_stub_p, trace_stub_f, trace_stub_r, trace_feed_jf, trace_res_open_run, trace_filter_tail, trace_res_tail, plate_cin, frame_cin, tap_trace_n0, tap_trace_jf, tap_trace_jr] MaxLength=20um
  cap_mesh: LengthBased Objects=[lead_a_cp, lead_b_cp, lead_a_cj, lead_b_cj, plate_cp, frame_cp, head_a_cj, head_b_cj] MaxLength=9um
setups:
  Setup: HfssEigen MinimumFrequency=5.95GHz NumModes=2 MaxDeltaFreq=0.1 ConvergeOnRealFreq=true MaximumPasses=8 MinimumPasses=3 MinimumConvergedPasses=2 PercentRefinement=20 BasisOrder=1
source amplitudes:
  #-10:1: 1 0deg
  #-10:2: 0 0deg
reports:
  Freq. vs. pass: re(Mode(1)), re(Mode(2)) vs Pass on Setup : AdaptivePass

design P400nh_cpwwb_m40um_2235_hfss (HFSS, Eigenmode, model units mm)
geometry:
  lead_a_cin_path = polyline((-0.000740499, 0, 0) (-0.0007925, 0, 0))
  lead_a_cin = polyline((-0.000740499, -5e-06, 0) (-0.000740499, 5e-06, 0))
  lead_a_cin.sweep_along_path(lead_a_cin_path)
  lead_a_sub_cin_path = polyline((-0.000740499, 0, 0) (-0.0007925, 0, 0))
  lead_a_sub_cin = polyline((-0.000740499, -1.1e-05, 0) (-0.000740499, 1.1e-05, 0))
  lead_a_sub_cin.sweep_along_path(lead_a_sub_cin_path)
  lead_b_cin_path = polyline((-0.000639501, 0, 0) (-0.0005275, 0, 0))
  lead_b_cin = polyline((-0.000639501, 5e-06, 0) (-0.000639501, -5e-06, 0))
  lead_b_cin.sweep_along_path(lead_b_cin_path)
  lead_b_sub_cin_path = polyline((-0.000639501, 0, 0) (-0.0005275, 0, 0))
  lead_b_sub_cin = polyline((-0.000639501, 1.1e-05, 0) (-0.000639501, -1.1e-05, 0))
  lead_b_sub_cin.sweep_along_path(lead_b_sub_cin_path)
  lead_a_cp_path = polyline((0, 0.000202001, 0) (0, 0.00015, 0))
  lead_a_cp = polyline((5e-06, 0.000202001, 0) (-5e-06, 0.000202001, 0))
  lead_a_cp.sweep_along_path(lead_a_cp_path)
  lead_a_sub_cp_path = polyline((0, 0.000202001, 0) (0, 0.00015, 0))
  lead_a_sub_cp = polyline((1.1e-05, 0.000202001, 0) (-1.1e-05, 0.000202001, 0))
  lead_a_sub_cp.sweep_along_path(lead_a_sub_cp_path)
  lead_b_cp_path = polyline((0, 0.000302999, 0) (0, 0.000415, 0))
  lead_b_cp = polyline((-5e-06, 0.000302999, 0) (5e-06, 0.000302999, 0))
  lead_b_cp.sweep_along_path(lead_b_cp_path)
  lead_b_sub_cp_path = polyline((0, 0.000302999, 0) (0, 0.000415, 0))
  lead_b_sub_cp = polyline((-1.1e-05, 0.000302999, 0) (1.1e-05, 0.000302999, 0))
  lead_b_sub_cp.sweep_along_path(lead_b_sub_cp_path)
  trace_feed_in_path = polyline((-0.00162, 0, 0) (-0.0007925, 0, 0))
  trace_feed_in = polyline((-0.00162, 5e-06, 0) (-0.00162, -5e-06, 0))
  trace_feed_in.sweep_along_path(trace_feed_in_path)
  cut_feed_in_path = polyline((-0.00162, 0, 0) (-0.0007925, 0, 0))
  cut_feed_in = polyline((-0.00162, 1.1e-05, 0) (-0.00162, -1.1e-05, 0))
  cut_feed_in.sweep_along_path(cut_feed_in_path)
  trace_feed_mid_path = polyline((-0.0005275, 0, 0) (-0.00015, 0, 0))
  trace_feed_mid = polyline((-0.0005275, 5e-06, 0) (-0.0005275, -5e-06, 0))
  trace_feed_mid.sweep_along_path(trace_feed_mid_path)
  cut_feed_mid_path = polyline((-0.0005275, 0, 0) (-0.00015, 0, 0))
  cut_feed_mid = polyline((-0.0005275, 1.1e-05, 0) (-0.0005275, -1.1e-05, 0))
  cut_feed_mid.sweep_along_path(cut_feed_mid_path)
  trace_feed_out_path = polyline((0.00015, 0, 0) (0.00162, 0, 0))
  trace_feed_out = polyline((0.00015, 5e-06, 0) (0.00015, -5e-06, 0))
  trace_feed_out.sweep_along_path(trace_feed_out_path)
  cut_feed_out_path = polyline((0.00015, 0, 0) (0.00162, 0, 0))
  cut_feed_out = polyline((0.00015, 1.1e-05, 0) (0.00015, -1.1e-05, 0))
  cut_feed_out.sweep_along_path(cut_feed_out_path)
  trace_stub_p_path = polyline((0, 0.0001, 0) (0, 0.00015, 0))
  trace_stub_p = polyline((-5e-06, 0.0001, 0) (5e-06, 0.0001, 0))
  trace_stub_p.sweep_along_path(trace_stub_p_path)
  cut_stub_p_path = polyline((0, 0.0001, 0) (0, 0.00015, 0))
  cut_stub_p = polyline((-1.1e-05, 0.0001, 0) (1.1e-05, 0.0001, 0))
  cut_stub_p.sweep_along_path(cut_stub_p_path)
  lead_a_sub_cj_path = polyline((3.0001e-05, 0.001615, 0) (2e-05, 0.001615, 0))
  lead_a_sub_cj = polyline((3.0001e-05, 0.001604, 0) (3.0001e-05, 0.001626, 0))
  lead_a_sub_cj.sweep_along_path(lead_a_sub_cj_path)
  lead_b_sub_cj_path = polyline((0.000369999, 0.001615, 0) (0.00038, 0.001615, 0))
  lead_b_sub_cj = polyline((0.000369999, 0.001626, 0) (0.000369999, 0.001604, 0))
  lead_b_sub_cj.sweep_along_path(lead_b_sub_cj_path)
  trace_stub_f_path = polyline((0, 0.001615, 0) (2e-05, 0.001615, 0))
  trace_stub_f = polyline((0, 0.00162, 0) (0, 0.00161, 0))
  trace_stub_f.sweep_along_path(trace_stub_f_path)
  cut_stub_f_path = polyline((0, 0.001615, 0) (2e-05, 0.001615, 0))
  cut_stub_f = polyline((0, 0.001626, 0) (0, 0.001604, 0))
  cut_stub_f.sweep_along_path(cut_stub_f_path)
  trace_stub_r_path = polyline((0.00038, 0.001615, 0) (0.0004, 0.001615, 0))
  trace_stub_r = polyline((0.00038, 0.00162, 0) (0.00038, 0.00161, 0))
  trace_stub_r.sweep_along_path(trace_stub_r_path)
  cut_stub_r_path = polyline((0.00038, 0.001615, 0) (0.0004, 0.001615, 0))
  cut_stub_r = polyline((0.00038, 0.001626, 0) (0.00038, 0.001604, 0))
  cut_stub_r.sweep_along_path(cut_stub_r_path)
  trace_feed_jf_path = polyline((0, 0.000415, 0) (0, 0.001465, 0))
  trace_feed_jf = polyline((-5e-06, 0.000415, 0) (5e-06, 0.000415, 0))
  trace_feed_jf.sweep_along_path(trace_feed_jf_path)
  cut_feed_jf_path = polyline((0, 0.000415, 0) (0, 0.001465, 0))
  cut_feed_jf = polyline((-1.1e-05, 0.000415, 0) (1.1e-05, 0.000415, 0))
  cut_feed_jf.sweep_along_path(cut_feed_jf_path)
  trace_res_open_run_path = polyline((0.0004, 0.001765, 0) (0.0004, 0.002915, 0))
  trace_res_open_run = polyline((0.000395, 0.001765, 0) (0.000405, 0.001765, 0))
  trace_res_open_run.sweep_along_path(trace_res_open_run_path)
  cut_res_open_run_path = polyline((0.0004, 0.001765, 0) (0.0004, 0.002915, 0))
  cut_res_open_run = polyline((0.000389, 0.001765, 0) (0.000411, 0.001765, 0))
  cut_res_open_run.sweep_along_path(cut_res_open_run_path)
  trace_filter_tail_path = polyline(z=0, xy: (0, 0.001765) (0, 0.002285) (-0.00051923387, 0.002285) (-0.00051923387, 0.002055) (-0.00025, 0.002055) (-0.00025, 0.001825) (-0.00051923387, 0.001825) (-0.00051923387, 0.001595) (-0.00025, 0.001595) (-0.00025, 0.001365) (-0.00051923387, 0.001365) (-0.00051923387, 0.001135))
  trace_filter_tail_path.fillet(Vertices=trace_filter_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  trace_filter_tail = polyline((-5e-06, 0.001765, 0) (5e-06, 0.001765, 0))
  trace_filter_tail.sweep_along_path(trace_filter_tail_path)
  cut_filter_tail_path = polyline(z=0, xy: (0, 0.001765) (0, 0.002285) (-0.00051923387, 0.002285) (-0.00051923387, 0.002055) (-0.00025, 0.002055) (-0.00025, 0.001825) (-0.00051923387, 0.001825) (-0.00051923387, 0.001595) (-0.00025, 0.001595) (-0.00025, 0.001365) (-0.00051923387, 0.001365) (-0.00051923387, 0.001135))
  cut_filter_tail_path.fillet(Vertices=cut_filter_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  cut_filter_tail = polyline((-1.1e-05, 0.001765, 0) (1.1e-05, 0.001765, 0))
  cut_filter_tail.sweep_along_path(cut_filter_tail_path)
  trace_res_tail_path = polyline(z=0, xy: (0.0004, 0.001465) (0.0004, 0.000765) (0.00092617693, 0.000765) (0.00092617693, 0.000995) (0.00065, 0.000995) (0.00065, 0.001225) (0.00092617693, 0.001225) (0.00092617693, 0.001455) (0.00065, 0.001455) (0.00065, 0.001685) (0.00092617693, 0.001685) (0.00092617693, 0.001875))
  trace_res_tail_path.fillet(Vertices=trace_res_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  trace_res_tail = polyline((0.000405, 0.001465, 0) (0.000395, 0.001465, 0))
  trace_res_tail.sweep_along_path(trace_res_tail_path)
  cut_res_tail_path = polyline(z=0, xy: (0.0004, 0.001465) (0.0004, 0.000765) (0.00092617693, 0.000765) (0.00092617693, 0.000995) (0.00065, 0.000995) (0.00065, 0.001225) (0.00092617693, 0.001225) (0.00092617693, 0.001455) (0.00065, 0.001455) (0.00065, 0.001685) (0.00092617693, 0.001685) (0.00092617693, 0.001875))
  cut_res_tail_path.fillet(Vertices=cut_res_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  cut_res_tail = polyline((0.000411, 0.001465, 0) (0.000389, 0.001465, 0))
  cut_res_tail.sweep_along_path(cut_res_tail_path)
  plate_cin = polyline(z=0, xy: (-0.0006725, -7e-05) (-0.00067328414, -6.9961478e-05) (-0.00067406072, -6.9846282e-05) (-0.00067482228, -6.9655523e-05) (-0.00067556147, -6.9391036e-05) (-0.00067627117, -6.905537e-05) (-0.00067694456, -6.8651757e-05) (-0.00067757515, -6.8184084e-05) (-0.00067815685, -6.7656854e-05) (-0.00067868408, -6.7075146e-05) (-0.00067915176, -6.6444562e-05) (-0.00067955537, -6.5771174e-05) (-0.00067989104, -6.5061467e-05) (-0.00068015552, -6.4322277e-05) (-0.00068034628, -6.3560723e-05) (-0.00068046148, -6.2784137e-05) (-0.0006805, -6.2e-05) (-0.0006805, 6.2e-05) (-0.00068046148, 6.2784137e-05) (-0.00068034628, 6.3560723e-05) (-0.00068015552, 6.4322277e-05) (-0.00067989104, 6.5061467e-05) (-0.00067955537, 6.5771174e-05) (-0.00067915176, 6.6444562e-05) (-0.00067868408, 6.7075146e-05) (-0.00067815685, 6.7656854e-05) (-0.00067757515, 6.8184084e-05) (-0.00067694456, 6.8651757e-05) (-0.00067627117, 6.905537e-05) (-0.00067556147, 6.9391036e-05) (-0.00067482228, 6.9655523e-05) (-0.00067406072, 6.9846282e-05) (-0.00067328414, 6.9961478e-05) (-0.0006725, 7e-05) (-0.0006475, 7e-05) (-0.00064671586, 6.9961478e-05) (-0.00064593928, 6.9846282e-05) (-0.00064517772, 6.9655523e-05) (-0.00064443853, 6.9391036e-05) (-0.00064372883, 6.905537e-05) (-0.00064305544, 6.8651757e-05) (-0.00064242485, 6.8184084e-05) (-0.00064184315, 6.7656854e-05) (-0.00064131592, 6.7075146e-05) (-0.00064084824, 6.6444562e-05) (-0.00064044463, 6.5771174e-05) (-0.00064010896, 6.5061467e-05) (-0.00063984448, 6.4322277e-05) (-0.00063965372, 6.3560723e-05) (-0.00063953852, 6.2784137e-05) (-0.0006395, 6.2e-05) (-0.0006395, -6.2e-05) (-0.00063953852, -6.2784137e-05) (-0.00063965372, -6.3560723e-05) (-0.00063984448, -6.4322277e-05) (-0.00064010896, -6.5061467e-05) (-0.00064044463, -6.5771174e-05) (-0.00064084824, -6.6444562e-05) (-0.00064131592, -6.7075146e-05) (-0.00064184315, -6.7656854e-05) (-0.00064242485, -6.8184084e-05) (-0.00064305544, -6.8651757e-05) (-0.00064372883, -6.905537e-05) (-0.00064443853, -6.9391036e-05) (-0.00064517772, -6.9655523e-05) (-0.00064593928, -6.9846282e-05) (-0.00064671586, -6.9961478e-05) (-0.0006475, -7e-05) (-0.0006725, -7e-05), closed, covered)
  frame_cin = polyline(z=0, xy: (-0.0006885, -7e-05) (-0.00068846148, -7.0784137e-05) (-0.00068834628, -7.1560723e-05) (-0.00068815552, -7.2322277e-05) (-0.00068789104, -7.3061467e-05) (-0.00068755537, -7.3771174e-05) (-0.00068715176, -7.4444562e-05) (-0.00068668408, -7.5075146e-05) (-0.00068615685, -7.5656854e-05) (-0.00068557515, -7.6184084e-05) (-0.00068494456, -7.6651757e-05) (-0.00068427117, -7.705537e-05) (-0.00068356147, -7.7391036e-05) (-0.00068282228, -7.7655523e-05) (-0.00068206072, -7.7846282e-05) (-0.00068128414, -7.7961478e-05) (-0.0006805, -7.8e-05) (-0.0006395, -7.8e-05) (-0.00063871586, -7.7961478e-05) (-0.00063793928, -7.7846282e-05) (-0.00063717772, -7.7655523e-05) (-0.00063643853, -7.7391036e-05) (-0.00063572883, -7.705537e-05) (-0.00063505544, -7.6651757e-05) (-0.00063442485, -7.6184084e-05) (-0.00063384315, -7.5656854e-05) (-0.00063331592, -7.5075146e-05) (-0.00063284824, -7.4444562e-05) (-0.00063244463, -7.3771174e-05) (-0.00063210896, -7.3061467e-05) (-0.00063184448, -7.2322277e-05) (-0.00063165372, -7.1560723e-05) (-0.00063153852, -7.0784137e-05) (-0.0006315, -7e-05) (-0.0006315, -1.909818e-05) (-0.00063149518, -1.8901939e-05) (-0.00063147111, -1.8412015e-05) (-0.00063143266, -1.80216e-05) (-0.0006313751, -1.7633541e-05) (-0.00063129856, -1.7248774e-05) (-0.00063120324, -1.6868226e-05) (-0.00063108936, -1.6492814e-05) (-0.0006309572, -1.6123441e-05) (-0.00063080707, -1.5760999e-05) (-0.00063063934, -1.540636e-05) (-0.00063045441, -1.5060378e-05) (-0.00063025272, -1.4723887e-05) (-0.00063003477, -1.4397697e-05) (-0.00062980107, -1.4082595e-05) (-0.0006295522, -1.3779339e-05) (-0.00062928874, -1.348866e-05) (-0.00062901134, -1.3211259e-05) (-0.00062872066, -1.2947803e-05) (-0.00062841741, -1.2698928e-05) (-0.0006281023, -1.2465232e-05) (-0.00062777611, -1.2247279e-05) (-0.00062743962, -1.2045594e-05) (-0.00062709364, -1.1860663e-05) (-0.000626739, -1.1692931e-05) (-0.00062637656, -1.1542802e-05) (-0.00062600719, -1.1410639e-05) (-0.00062563177, -1.1296759e-05) (-0.00062525123, -1.1201436e-05) (-0.00062486646, -1.1124902e-05) (-0.0006244784, -1.1067338e-05) (-0.00062408799, -1.1028886e-05) (-0.00062359806, -1.1004817e-05) (-0.00062340182, -1.1e-05) (-0.00057559818, -1.1e-05) (-0.00057540194, -1.1004817e-05) (-0.00057491201, -1.1028886e-05) (-0.0005745216, -1.1067338e-05) (-0.00057413354, -1.1124902e-05) (-0.00057374877, -1.1201436e-05) (-0.00057336823, -1.1296759e-05) (-0.00057299281, -1.1410639e-05) (-0.00057262344, -1.1542802e-05) (-0.000572261, -1.1692931e-05) (-0.00057190636, -1.1860663e-05) (-0.00057156038, -1.2045594e-05) (-0.00057122389, -1.2247279e-05) (-0.0005708977, -1.2465232e-05) (-0.0005705826, -1.2698928e-05) (-0.00057027934, -1.2947803e-05) (-0.00056998866, -1.3211259e-05) (-0.00056971126, -1.348866e-05) (-0.0005694478, -1.3779339e-05) (-0.00056919893, -1.4082595e-05) (-0.00056896523, -1.4397697e-05) (-0.00056874728, -1.4723887e-05) (-0.00056854559, -1.5060378e-05) (-0.00056836066, -1.540636e-05) (-0.00056819293, -1.5760999e-05) (-0.0005680428, -1.6123441e-05) (-0.00056791064, -1.6492814e-05) (-0.00056779676, -1.6868226e-05) (-0.00056770144, -1.7248774e-05) (-0.0005676249, -1.7633541e-05) (-0.00056756734, -1.80216e-05) (-0.00056752889, -1.8412015e-05) (-0.00056750482, -1.8901939e-05) (-0.0005675, -1.909818e-05) (-0.0005675, -0.00012690182) (-0.00056750482, -0.00012709806) (-0.00056752889, -0.00012758798) (-0.00056756734, -0.0001279784) (-0.0005676249, -0.00012836646) (-0.00056770144, -0.00012875123) (-0.00056779676, -0.00012913177) (-0.00056791064, -0.00012950719) (-0.0005680428, -0.00012987656) (-0.00056819293, -0.000130239) (-0.00056836066, -0.00013059364) (-0.00056854559, -0.00013093962) (-0.00056874728, -0.00013127611) (-0.00056896523, -0.0001316023) (-0.00056919893, -0.00013191741) (-0.0005694478, -0.00013222066) (-0.00056971126, -0.00013251134) (-0.00056998866, -0.00013278874) (-0.00057027934, -0.0001330522) (-0.0005705826, -0.00013330107) (-0.0005708977, -0.00013353477) (-0.00057122389, -0.00013375272) (-0.00057156038, -0.00013395441) (-0.00057190636, -0.00013413934) (-0.000572261, -0.00013430707) (-0.00057262344, -0.0001344572) (-0.00057299281, -0.00013458936) (-0.00057336823, -0.00013470324) (-0.00057374877, -0.00013479856) (-0.00057413354, -0.0001348751) (-0.0005745216, -0.00013493266) (-0.00057491201, -0.00013497111) (-0.00057540194, -0.00013499518) (-0.00057559818, -0.000135) (-0.00073240182, -0.000135) (-0.00073259806, -0.00013499518) (-0.00073308798, -0.00013497111) (-0.0007334784, -0.00013493266) (-0.00073386646, -0.0001348751) (-0.00073425123, -0.00013479856) (-0.00073463177, -0.00013470324) (-0.00073500719, -0.00013458936) (-0.00073537656, -0.0001344572) (-0.000735739, -0.00013430707) (-0.00073609364, -0.00013413934) (-0.00073643962, -0.00013395441) (-0.00073677611, -0.00013375272) (-0.0007371023, -0.00013353477) (-0.0007374174, -0.00013330107) (-0.00073772066, -0.0001330522) (-0.00073801134, -0.00013278874) (-0.00073828874, -0.00013251134) (-0.0007385522, -0.00013222066) (-0.00073880107, -0.00013191741) (-0.00073903477, -0.0001316023) (-0.00073925272, -0.00013127611) (-0.00073945441, -0.00013093962) (-0.00073963934, -0.00013059364) (-0.00073980707, -0.000130239) (-0.0007399572, -0.00012987656) (-0.00074008936, -0.00012950719) (-0.00074020324, -0.00012913177) (-0.00074029856, -0.00012875123) (-0.0007403751, -0.00012836646) (-0.00074043266, -0.0001279784) (-0.00074047111, -0.00012758798) (-0.00074049518, -0.00012709806) (-0.0007405, -0.00012690182) (-0.0007405, 0.00012690182) (-0.00074049518, 0.00012709806) (-0.00074047111, 0.00012758798) (-0.00074043266, 0.0001279784) (-0.0007403751, 0.00012836646) (-0.00074029856, 0.00012875123) (-0.00074020324, 0.00012913177) (-0.00074008936, 0.00012950719) (-0.0007399572, 0.00012987656) (-0.00073980707, 0.000130239) (-0.00073963934, 0.00013059364) (-0.00073945441, 0.00013093962) (-0.00073925272, 0.00013127611) (-0.00073903477, 0.0001316023) (-0.00073880107, 0.00013191741) (-0.0007385522, 0.00013222066) (-0.00073828874, 0.00013251134) (-0.00073801134, 0.00013278874) (-0.00073772066, 0.0001330522) (-0.0007374174, 0.00013330107) (-0.0007371023, 0.00013353477) (-0.00073677611, 0.00013375272) (-0.00073643962, 0.00013395441) (-0.00073609364, 0.00013413934) (-0.000735739, 0.00013430707) (-0.00073537656, 0.0001344572) (-0.00073500719, 0.00013458936) (-0.00073463177, 0.00013470324) (-0.00073425123, 0.00013479856) (-0.00073386646, 0.0001348751) (-0.0007334784, 0.00013493266) (-0.00073308798, 0.00013497111) (-0.00073259806, 0.00013499518) (-0.00073240182, 0.000135) (-0.00057559818, 0.000135) (-0.00057540194, 0.00013499518) (-0.00057491201, 0.00013497111) (-0.0005745216, 0.00013493266) (-0.00057413354, 0.0001348751) (-0.00057374877, 0.00013479856) (-0.00057336823, 0.00013470324) (-0.00057299281, 0.00013458936) (-0.00057262344, 0.0001344572) (-0.000572261, 0.00013430707) (-0.00057190636, 0.00013413934) (-0.00057156038, 0.00013395441) (-0.00057122389, 0.00013375272) (-0.0005708977, 0.00013353477) (-0.0005705826, 0.00013330107) (-0.00057027934, 0.0001330522) (-0.00056998866, 0.00013278874) (-0.00056971126, 0.00013251134) (-0.0005694478, 0.00013222066) (-0.00056919893, 0.00013191741) (-0.00056896523, 0.0001316023) (-0.00056874728, 0.00013127611) (-0.00056854559, 0.00013093962) (-0.00056836066, 0.00013059364) (-0.00056819293, 0.000130239) (-0.0005680428, 0.00012987656) (-0.00056791064, 0.00012950719) (-0.00056779676, 0.00012913177) (-0.00056770144, 0.00012875123) (-0.0005676249, 0.00012836646) (-0.00056756734, 0.0001279784) (-0.00056752889, 0.00012758798) (-0.00056750482, 0.00012709806) (-0.0005675, 0.00012690182) (-0.0005675, 1.909818e-05) (-0.00056750482, 1.8901939e-05) (-0.00056752889, 1.8412015e-05) (-0.00056756734, 1.80216e-05) (-0.0005676249, 1.7633541e-05) (-0.00056770144, 1.7248774e-05) (-0.00056779676, 1.6868226e-05) (-0.00056791064, 1.6492814e-05) (-0.0005680428, 1.6123441e-05) (-0.00056819293, 1.5760999e-05) (-0.00056836066, 1.540636e-05) (-0.00056854559, 1.5060378e-05) (-0.00056874728, 1.4723887e-05) (-0.00056896523, 1.4397697e-05) (-0.00056919893, 1.4082595e-05) (-0.0005694478, 1.3779339e-05) (-0.00056971126, 1.348866e-05) (-0.00056998866, 1.3211259e-05) (-0.00057027934, 1.2947803e-05) (-0.0005705826, 1.2698928e-05) (-0.0005708977, 1.2465232e-05) (-0.00057122389, 1.2247279e-05) (-0.00057156038, 1.2045594e-05) (-0.00057190636, 1.1860663e-05) (-0.000572261, 1.1692931e-05) (-0.00057262344, 1.1542802e-05) (-0.00057299281, 1.1410639e-05) (-0.00057336823, 1.1296759e-05) (-0.00057374877, 1.1201436e-05) (-0.00057413354, 1.1124902e-05) (-0.0005745216, 1.1067338e-05) (-0.00057491201, 1.1028886e-05) (-0.00057540194, 1.1004817e-05) (-0.00057559818, 1.1e-05) (-0.00062340182, 1.1e-05) (-0.00062359806, 1.1004817e-05) (-0.00062408799, 1.1028886e-05) (-0.0006244784, 1.1067338e-05) (-0.00062486646, 1.1124902e-05) (-0.00062525123, 1.1201436e-05) (-0.00062563177, 1.1296759e-05) (-0.00062600719, 1.1410639e-05) (-0.00062637656, 1.1542802e-05) (-0.000626739, 1.1692931e-05) (-0.00062709364, 1.1860663e-05) (-0.00062743962, 1.2045594e-05) (-0.00062777611, 1.2247279e-05) (-0.0006281023, 1.2465232e-05) (-0.00062841741, 1.2698928e-05) (-0.00062872066, 1.2947803e-05) (-0.00062901134, 1.3211259e-05) (-0.00062928874, 1.348866e-05) (-0.0006295522, 1.3779339e-05) (-0.00062980107, 1.4082595e-05) (-0.00063003477, 1.4397697e-05) (-0.00063025272, 1.4723887e-05) (-0.00063045441, 1.5060378e-05) (-0.00063063934, 1.540636e-05) (-0.00063080707, 1.5760999e-05) (-0.0006309572, 1.6123441e-05) (-0.00063108936, 1.6492814e-05) (-0.00063120324, 1.6868226e-05)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, closed, covered)
  pocket_cin = polyline(z=0, xy: (-0.0007525, -0.000135) (-0.0007525, 0.000135) (-0.00075244222, 0.00013617621) (-0.00075226942, 0.00013734108) (-0.00075198328, 0.00013848342) (-0.00075158655, 0.0001395922) (-0.00075108306, 0.00014065676) (-0.00075047764, 0.00014166684) (-0.00074977613, 0.00014261272) (-0.00074898528, 0.00014348528) (-0.00074811272, 0.00014427613) (-0.00074716684, 0.00014497764) (-0.00074615676, 0.00014558305) (-0.0007450922, 0.00014608655) (-0.00074398342, 0.00014648328) (-0.00074284108, 0.00014676942) (-0.00074167621, 0.00014694222) (-0.0007405, 0.000147) (-0.0005675, 0.000147) (-0.00056632379, 0.00014694222) (-0.00056515892, 0.00014676942) (-0.00056401658, 0.00014648328) (-0.0005629078, 0.00014608655) (-0.00056184324, 0.00014558305) (-0.00056083316, 0.00014497764) (-0.00055988728, 0.00014427613) (-0.00055901472, 0.00014348528) (-0.00055822388, 0.00014261272) (-0.00055752237, 0.00014166684) (-0.00055691694, 0.00014065676) (-0.00055641345, 0.0001395922) (-0.00055601672, 0.00013848342) (-0.00055573058, 0.00013734108) (-0.00055555778, 0.00013617621) (-0.0005555, 0.000135) (-0.0005555, -0.000135) (-0.00055555778, -0.00013617621) (-0.00055573058, -0.00013734108) (-0.00055601672, -0.00013848342) (-0.00055641345, -0.0001395922) (-0.00055691694, -0.00014065676) (-0.00055752237, -0.00014166684) (-0.00055822388, -0.00014261272) (-0.00055901472, -0.00014348528) (-0.00055988728, -0.00014427613) (-0.00056083316, -0.00014497764) (-0.00056184324, -0.00014558305) (-0.0005629078, -0.00014608655) (-0.00056401658, -0.00014648328) (-0.00056515892, -0.00014676942) (-0.00056632379, -0.00014694222) (-0.0005675, -0.000147) (-0.0007405, -0.000147) (-0.00074167621, -0.00014694222) (-0.00074284108, -0.00014676942) (-0.00074398342, -0.00014648328) (-0.0007450922, -0.00014608655) (-0.00074615676, -0.00014558305) (-0.00074716684, -0.00014497764) (-0.00074811272, -0.00014427613) (-0.00074898528, -0.00014348528) (-0.00074977613, -0.00014261272) (-0.00075047764, -0.00014166684) (-0.00075108306, -0.00014065676) (-0.00075158655, -0.0001395922) (-0.00075198328, -0.00013848342) (-0.00075226942, -0.00013734108) (-0.00075244222, -0.00013617621) (-0.0007525, -0.000135), closed, covered)
  tap_trace_n0 = polyline(z=0, xy: (0.00015, -5e-06) (-0.00015, -5e-06) (-0.00015, 5e-06) (-5e-06, 5e-06) (-5e-06, 0.0001) (5e-06, 0.0001) (5e-06, 5e-06) (0.00015, 5e-06) (0.00015, -5e-06), closed, covered)
  tap_cut_n0 = polyline(z=0, xy: (0.00015, -1.1e-05) (-0.00015, -1.1e-05) (-0.00015, 1.1e-05) (-1.1e-05, 1.1e-05) (-1.1e-05, 0.0001) (1.1e-05, 0.0001) (1.1e-05, 1.1e-05) (0.00015, 1.1e-05) (0.00015, -1.1e-05), closed, covered)
  plate_cp = polyline(z=0, xy: (7e-05, 0.00027) (6.9961478e-05, 0.00026921586) (6.9846282e-05, 0.00026843928) (6.9655523e-05, 0.00026767772) (6.9391036e-05, 0.00026693853) (6.905537e-05, 0.00026622883) (6.8651757e-05, 0.00026555544) (6.8184084e-05, 0.00026492485) (6.7656854e-05, 0.00026434315) (6.7075146e-05, 0.00026381592) (6.6444562e-05, 0.00026334824) (6.5771174e-05, 0.00026294463) (6.5061467e-05, 0.00026260896) (6.4322277e-05, 0.00026234448) (6.3560723e-05, 0.00026215372) (6.2784137e-05, 0.00026203852) (6.2e-05, 0.000262) (-6.2e-05, 0.000262) (-6.2784137e-05, 0.00026203852) (-6.3560723e-05, 0.00026215372) (-6.4322277e-05, 0.00026234448) (-6.5061467e-05, 0.00026260896) (-6.5771174e-05, 0.00026294463) (-6.6444562e-05, 0.00026334824) (-6.7075146e-05, 0.00026381592) (-6.7656854e-05, 0.00026434315) (-6.8184084e-05, 0.00026492485) (-6.8651757e-05, 0.00026555544) (-6.905537e-05, 0.00026622883) (-6.9391036e-05, 0.00026693853) (-6.9655523e-05, 0.00026767772) (-6.9846282e-05, 0.00026843928) (-6.9961478e-05, 0.00026921586) (-7e-05, 0.00027) (-7e-05, 0.000295) (-6.9961478e-05, 0.00029578414) (-6.9846282e-05, 0.00029656072) (-6.9655523e-05, 0.00029732228) (-6.9391036e-05, 0.00029806147) (-6.905537e-05, 0.00029877117) (-6.8651757e-05, 0.00029944456) (-6.8184084e-05, 0.00030007515) (-6.7656854e-05, 0.00030065685) (-6.7075146e-05, 0.00030118408) (-6.6444562e-05, 0.00030165176) (-6.5771174e-05, 0.00030205537) (-6.5061467e-05, 0.00030239104) (-6.4322277e-05, 0.00030265552) (-6.3560723e-05, 0.00030284628) (-6.2784137e-05, 0.00030296148) (-6.2e-05, 0.000303) (6.2e-05, 0.000303) (6.2784137e-05, 0.00030296148) (6.3560723e-05, 0.00030284628) (6.4322277e-05, 0.00030265552) (6.5061467e-05, 0.00030239104) (6.5771174e-05, 0.00030205537) (6.6444562e-05, 0.00030165176) (6.7075146e-05, 0.00030118408) (6.7656854e-05, 0.00030065685) (6.8184084e-05, 0.00030007515) (6.8651757e-05, 0.00029944456) (6.905537e-05, 0.00029877117) (6.9391036e-05, 0.00029806147) (6.9655523e-05, 0.00029732228) (6.9846282e-05, 0.00029656072) (6.9961478e-05, 0.00029578414) (7e-05, 0.000295) (7e-05, 0.00027), closed, covered)
  frame_cp = polyline(z=0, xy: (7e-05, 0.000254) (7.0784137e-05, 0.00025403852) (7.1560723e-05, 0.00025415372) (7.2322277e-05, 0.00025434448) (7.3061467e-05, 0.00025460896) (7.3771174e-05, 0.00025494463) (7.4444562e-05, 0.00025534824) (7.5075146e-05, 0.00025581592) (7.5656854e-05, 0.00025634315) (7.6184084e-05, 0.00025692485) (7.6651757e-05, 0.00025755544) (7.705537e-05, 0.00025822883) (7.7391036e-05, 0.00025893853) (7.7655523e-05, 0.00025967772) (7.7846282e-05, 0.00026043928) (7.7961478e-05, 0.00026121586) (7.8e-05, 0.000262) (7.8e-05, 0.000303) (7.7961478e-05, 0.00030378414) (7.7846282e-05, 0.00030456072) (7.7655523e-05, 0.00030532228) (7.7391036e-05, 0.00030606147) (7.705537e-05, 0.00030677117) (7.6651757e-05, 0.00030744456) (7.6184084e-05, 0.00030807515) (7.5656854e-05, 0.00030865685) (7.5075146e-05, 0.00030918408) (7.4444562e-05, 0.00030965176) (7.3771174e-05, 0.00031005537) (7.3061467e-05, 0.00031039104) (7.2322277e-05, 0.00031065552) (7.1560723e-05, 0.00031084628) (7.0784137e-05, 0.00031096148) (7e-05, 0.000311) (1.909818e-05, 0.000311) (1.8901939e-05, 0.00031100482) (1.8412015e-05, 0.00031102889) (1.80216e-05, 0.00031106734) (1.7633541e-05, 0.0003111249) (1.7248774e-05, 0.00031120144) (1.6868226e-05, 0.00031129676) (1.6492814e-05, 0.00031141064) (1.6123441e-05, 0.0003115428) (1.5760999e-05, 0.00031169293) (1.540636e-05, 0.00031186066) (1.5060378e-05, 0.00031204559) (1.4723887e-05, 0.00031224728) (1.4397697e-05, 0.00031246523) (1.4082595e-05, 0.00031269893) (1.3779339e-05, 0.0003129478) (1.348866e-05, 0.00031321126) (1.3211259e-05, 0.00031348866) (1.2947803e-05, 0.00031377934) (1.2698928e-05, 0.00031408259) (1.2465232e-05, 0.0003143977) (1.2247279e-05, 0.00031472389) (1.2045594e-05, 0.00031506038) (1.1860663e-05, 0.00031540636) (1.1692931e-05, 0.000315761) (1.1542802e-05, 0.00031612344) (1.1410639e-05, 0.00031649281) (1.1296759e-05, 0.00031686823) (1.1201436e-05, 0.00031724877) (1.1124902e-05, 0.00031763354) (1.1067338e-05, 0.0003180216) (1.1028886e-05, 0.00031841202) (1.1004817e-05, 0.00031890194) (1.1e-05, 0.00031909818) (1.1e-05, 0.00036690182) (1.1004817e-05, 0.00036709806) (1.1028886e-05, 0.00036758799) (1.1067338e-05, 0.0003679784) (1.1124902e-05, 0.00036836646) (1.1201436e-05, 0.00036875123) (1.1296759e-05, 0.00036913177) (1.1410639e-05, 0.00036950719) (1.1542802e-05, 0.00036987656) (1.1692931e-05, 0.000370239) (1.1860663e-05, 0.00037059364) (1.2045594e-05, 0.00037093962) (1.2247279e-05, 0.00037127611) (1.2465232e-05, 0.0003716023) (1.2698928e-05, 0.0003719174) (1.2947803e-05, 0.00037222066) (1.3211259e-05, 0.00037251134) (1.348866e-05, 0.00037278874) (1.3779339e-05, 0.0003730522) (1.4082595e-05, 0.00037330107) (1.4397697e-05, 0.00037353477) (1.4723887e-05, 0.00037375272) (1.5060378e-05, 0.00037395441) (1.540636e-05, 0.00037413934) (1.5760999e-05, 0.00037430707) (1.6123441e-05, 0.0003744572) (1.6492814e-05, 0.00037458936) (1.6868226e-05, 0.00037470324) (1.7248774e-05, 0.00037479856) (1.7633541e-05, 0.0003748751) (1.80216e-05, 0.00037493266) (1.8412015e-05, 0.00037497111) (1.8901939e-05, 0.00037499518) (1.909818e-05, 0.000375) (0.00012690182, 0.000375) (0.00012709806, 0.00037499518) (0.00012758798, 0.00037497111) (0.0001279784, 0.00037493266) (0.00012836646, 0.0003748751) (0.00012875123, 0.00037479856) (0.00012913177, 0.00037470324) (0.00012950719, 0.00037458936) (0.00012987656, 0.0003744572) (0.000130239, 0.00037430707) (0.00013059364, 0.00037413934) (0.00013093962, 0.00037395441) (0.00013127611, 0.00037375272) (0.0001316023, 0.00037353477) (0.00013191741, 0.00037330107) (0.00013222066, 0.0003730522) (0.00013251134, 0.00037278874) (0.00013278874, 0.00037251134) (0.0001330522, 0.00037222066) (0.00013330107, 0.0003719174) (0.00013353477, 0.0003716023) (0.00013375272, 0.00037127611) (0.00013395441, 0.00037093962) (0.00013413934, 0.00037059364) (0.00013430707, 0.000370239) (0.0001344572, 0.00036987656) (0.00013458936, 0.00036950719) (0.00013470324, 0.00036913177) (0.00013479856, 0.00036875123) (0.0001348751, 0.00036836646) (0.00013493266, 0.0003679784) (0.00013497111, 0.00036758799) (0.00013499518, 0.00036709806) (0.000135, 0.00036690182) (0.000135, 0.00021009818) (0.00013499518, 0.00020990194) (0.00013497111, 0.00020941201) (0.00013493266, 0.0002090216) (0.0001348751, 0.00020863354) (0.00013479856, 0.00020824877) (0.00013470324, 0.00020786823) (0.00013458936, 0.00020749281) (0.0001344572, 0.00020712344) (0.00013430707, 0.000206761) (0.00013413934, 0.00020640636) (0.00013395441, 0.00020606038) (0.00013375272, 0.00020572389) (0.00013353477, 0.0002053977) (0.00013330107, 0.00020508259) (0.0001330522, 0.00020477934) (0.00013278874, 0.00020448866) (0.00013251134, 0.00020421126) (0.00013222066, 0.0002039478) (0.00013191741, 0.00020369893) (0.0001316023, 0.00020346523) (0.00013127611, 0.00020324728) (0.00013093962, 0.00020304559) (0.00013059364, 0.00020286066) (0.000130239, 0.00020269293) (0.00012987656, 0.0002025428) (0.00012950719, 0.00020241064) (0.00012913177, 0.00020229676) (0.00012875123, 0.00020220144) (0.00012836646, 0.0002021249) (0.0001279784, 0.00020206734) (0.00012758798, 0.00020202889) (0.00012709806, 0.00020200482) (0.00012690182, 0.000202) (-0.00012690182, 0.000202) (-0.00012709806, 0.00020200482) (-0.00012758798, 0.00020202889) (-0.0001279784, 0.00020206734) (-0.00012836646, 0.0002021249) (-0.00012875123, 0.00020220144) (-0.00012913177, 0.00020229676) (-0.00012950719, 0.00020241064) (-0.00012987656, 0.0002025428) (-0.000130239, 0.00020269293) (-0.00013059364, 0.00020286066) (-0.00013093962, 0.00020304559) (-0.00013127611, 0.00020324728) (-0.0001316023, 0.00020346523) (-0.00013191741, 0.00020369893) (-0.00013222066, 0.0002039478) (-0.00013251134, 0.00020421126) (-0.00013278874, 0.00020448866) (-0.0001330522, 0.00020477934) (-0.00013330107, 0.00020508259) (-0.00013353477, 0.0002053977) (-0.00013375272, 0.00020572389) (-0.00013395441, 0.00020606038) (-0.00013413934, 0.00020640636) (-0.00013430707, 0.000206761) (-0.0001344572, 0.00020712344) (-0.00013458936, 0.00020749281) (-0.00013470324, 0.00020786823) (-0.00013479856, 0.00020824877) (-0.0001348751, 0.00020863354) (-0.00013493266, 0.0002090216) (-0.00013497111, 0.00020941201) (-0.00013499518, 0.00020990194) (-0.000135, 0.00021009818) (-0.000135, 0.00036690182) (-0.00013499518, 0.00036709806) (-0.00013497111, 0.00036758799) (-0.00013493266, 0.0003679784) (-0.0001348751, 0.00036836646) (-0.00013479856, 0.00036875123) (-0.00013470324, 0.00036913177) (-0.00013458936, 0.00036950719) (-0.0001344572, 0.00036987656) (-0.00013430707, 0.000370239) (-0.00013413934, 0.00037059364) (-0.00013395441, 0.00037093962) (-0.00013375272, 0.00037127611) (-0.00013353477, 0.0003716023) (-0.00013330107, 0.0003719174) (-0.0001330522, 0.00037222066) (-0.00013278874, 0.00037251134) (-0.00013251134, 0.00037278874) (-0.00013222066, 0.0003730522) (-0.00013191741, 0.00037330107) (-0.0001316023, 0.00037353477) (-0.00013127611, 0.00037375272) (-0.00013093962, 0.00037395441) (-0.00013059364, 0.00037413934) (-0.000130239, 0.00037430707) (-0.00012987656, 0.0003744572) (-0.00012950719, 0.00037458936) (-0.00012913177, 0.00037470324) (-0.00012875123, 0.00037479856) (-0.00012836646, 0.0003748751) (-0.0001279784, 0.00037493266) (-0.00012758798, 0.00037497111) (-0.00012709806, 0.00037499518) (-0.00012690182, 0.000375) (-1.909818e-05, 0.000375) (-1.8901939e-05, 0.00037499518) (-1.8412015e-05, 0.00037497111) (-1.80216e-05, 0.00037493266) (-1.7633541e-05, 0.0003748751) (-1.7248774e-05, 0.00037479856) (-1.6868226e-05, 0.00037470324) (-1.6492814e-05, 0.00037458936) (-1.6123441e-05, 0.0003744572) (-1.5760999e-05, 0.00037430707) (-1.540636e-05, 0.00037413934) (-1.5060378e-05, 0.00037395441) (-1.4723887e-05, 0.00037375272) (-1.4397697e-05, 0.00037353477) (-1.4082595e-05, 0.00037330107) (-1.3779339e-05, 0.0003730522) (-1.348866e-05, 0.00037278874) (-1.3211259e-05, 0.00037251134) (-1.2947803e-05, 0.00037222066) (-1.2698928e-05, 0.0003719174) (-1.2465232e-05, 0.0003716023) (-1.2247279e-05, 0.00037127611) (-1.2045594e-05, 0.00037093962) (-1.1860663e-05, 0.00037059364) (-1.1692931e-05, 0.000370239) (-1.1542802e-05, 0.00036987656) (-1.1410639e-05, 0.00036950719) (-1.1296759e-05, 0.00036913177) (-1.1201436e-05, 0.00036875123) (-1.1124902e-05, 0.00036836646) (-1.1067338e-05, 0.0003679784) (-1.1028886e-05, 0.00036758799) (-1.1004817e-05, 0.00036709806) (-1.1e-05, 0.00036690182) (-1.1e-05, 0.00031909818) (-1.1004817e-05, 0.00031890194) (-1.1028886e-05, 0.00031841202) (-1.1067338e-05, 0.0003180216) (-1.1124902e-05, 0.00031763354) (-1.1201436e-05, 0.00031724877) (-1.1296759e-05, 0.00031686823) (-1.1410639e-05, 0.00031649281) (-1.1542802e-05, 0.00031612344) (-1.1692931e-05, 0.000315761) (-1.1860663e-05, 0.00031540636) (-1.2045594e-05, 0.00031506038) (-1.2247279e-05, 0.00031472389) (-1.2465232e-05, 0.0003143977) (-1.2698928e-05, 0.00031408259) (-1.2947803e-05, 0.00031377934) (-1.3211259e-05, 0.00031348866) (-1.348866e-05, 0.00031321126) (-1.3779339e-05, 0.0003129478) (-1.4082595e-05, 0.00031269893) (-1.4397697e-05, 0.00031246523) (-1.4723887e-05, 0.00031224728) (-1.5060378e-05, 0.00031204559) (-1.540636e-05, 0.00031186066) (-1.5760999e-05, 0.00031169293) (-1.6123441e-05, 0.0003115428) (-1.6492814e-05, 0.00031141064) (-1.6868226e-05, 0.00031129676)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, closed, covered)
  pocket_cp = polyline(z=0, xy: (0.000135, 0.00019) (-0.000135, 0.00019) (-0.00013617621, 0.00019005778) (-0.00013734108, 0.00019023058) (-0.00013848342, 0.00019051672) (-0.0001395922, 0.00019091345) (-0.00014065676, 0.00019141694) (-0.00014166684, 0.00019202237) (-0.00014261272, 0.00019272388) (-0.00014348528, 0.00019351472) (-0.00014427613, 0.00019438728) (-0.00014497764, 0.00019533316) (-0.00014558305, 0.00019634324) (-0.00014608655, 0.0001974078) (-0.00014648328, 0.00019851658) (-0.00014676942, 0.00019965892) (-0.00014694222, 0.00020082379) (-0.000147, 0.000202) (-0.000147, 0.000375) (-0.00014694222, 0.00037617621) (-0.00014676942, 0.00037734108) (-0.00014648328, 0.00037848342) (-0.00014608655, 0.0003795922) (-0.00014558305, 0.00038065676) (-0.00014497764, 0.00038166684) (-0.00014427613, 0.00038261272) (-0.00014348528, 0.00038348528) (-0.00014261272, 0.00038427613) (-0.00014166684, 0.00038497764) (-0.00014065676, 0.00038558305) (-0.0001395922, 0.00038608655) (-0.00013848342, 0.00038648328) (-0.00013734108, 0.00038676942) (-0.00013617621, 0.00038694222) (-0.000135, 0.000387) (0.000135, 0.000387) (0.00013617621, 0.00038694222) (0.00013734108, 0.00038676942) (0.00013848342, 0.00038648328) (0.0001395922, 0.00038608655) (0.00014065676, 0.00038558305) (0.00014166684, 0.00038497764) (0.00014261272, 0.00038427613) (0.00014348528, 0.00038348528) (0.00014427613, 0.00038261272) (0.00014497764, 0.00038166684) (0.00014558305, 0.00038065676) (0.00014608655, 0.0003795922) (0.00014648328, 0.00037848342) (0.00014676942, 0.00037734108) (0.00014694222, 0.00037617621) (0.000147, 0.000375) (0.000147, 0.000202) (0.00014694222, 0.00020082379) (0.00014676942, 0.00019965892) (0.00014648328, 0.00019851658) (0.00014608655, 0.0001974078) (0.00014558305, 0.00019634324) (0.00014497764, 0.00019533316) (0.00014427613, 0.00019438728) (0.00014348528, 0.00019351472) (0.00014261272, 0.00019272388) (0.00014166684, 0.00019202237) (0.00014065676, 0.00019141694) (0.0001395922, 0.00019091345) (0.00013848342, 0.00019051672) (0.00013734108, 0.00019023058) (0.00013617621, 0.00019005778) (0.000135, 0.00019), closed, covered)
  tap_trace_jf = rectangle(corner=(-5e-06, 0.001465, 0), x_size=1e-05, y_size=0.0003)
  tap_cut_jf = rectangle(corner=(-1.1e-05, 0.001465, 0), x_size=2.2e-05, y_size=0.0003)
  tap_trace_jr = rectangle(corner=(0.000395, 0.001465, 0), x_size=1e-05, y_size=0.0003)
  tap_cut_jr = rectangle(corner=(0.000389, 0.001465, 0), x_size=2.2e-05, y_size=0.0003)
  pocket_cj = polyline(z=0, xy: (2.1803966e-05, 0.0015860096) (2.1609819e-05, 0.0015860384) (2.1419431e-05, 0.0015860861) (2.1234633e-05, 0.0015861522) (2.1057207e-05, 0.0015862362) (2.088886e-05, 0.0015863371) (2.0731213e-05, 0.001586454) (2.0585786e-05, 0.0015865858) (2.0453979e-05, 0.0015867312) (2.0337061e-05, 0.0015868889) (2.0236157e-05, 0.0015870572) (2.0152241e-05, 0.0015872346) (2.0086119e-05, 0.0015874194) (2.0038429e-05, 0.0015876098) (2.0009631e-05, 0.001587804) (2e-05, 0.001588) (2e-05, 0.001642) (2.0009631e-05, 0.001642196) (2.0038429e-05, 0.0016423902) (2.0086119e-05, 0.0016425806) (2.0152241e-05, 0.0016427654) (2.0236157e-05, 0.0016429428) (2.0337061e-05, 0.0016431111) (2.0453979e-05, 0.0016432688) (2.0585786e-05, 0.0016434142) (2.0731213e-05, 0.001643546) (2.088886e-05, 0.0016436629) (2.1057207e-05, 0.0016437638) (2.1234633e-05, 0.0016438478) (2.1419431e-05, 0.0016439139) (2.1609819e-05, 0.0016439616) (2.1803966e-05, 0.0016439904) (2.2e-05, 0.001644) (9.5e-05, 0.001644) (9.5e-05, 0.001586) (2.2e-05, 0.001586) (2.1803966e-05, 0.0015860096), closed, covered)
  open_to_ground_readout_open = rectangle(corner=(0.000389, 0.002915, 0), x_size=2.2e-05, y_size=6e-06)
  pocket_r_cj = polyline(z=0, xy: (0.000378, 0.001644) (0.00037819603, 0.0016439904) (0.00037839018, 0.0016439616) (0.00037858057, 0.0016439139) (0.00037876537, 0.0016438478) (0.00037894279, 0.0016437638) (0.00037911114, 0.0016436629) (0.00037926879, 0.001643546) (0.00037941421, 0.0016434142) (0.00037954602, 0.0016432688) (0.00037966294, 0.0016431111) (0.00037976384, 0.0016429428) (0.00037984776, 0.0016427654) (0.00037991388, 0.0016425806) (0.00037996157, 0.0016423902) (0.00037999037, 0.001642196) (0.00038, 0.001642) (0.00038, 0.001588) (0.00037999037, 0.001587804) (0.00037996157, 0.0015876098) (0.00037991388, 0.0015874194) (0.00037984776, 0.0015872346) (0.00037976384, 0.0015870572) (0.00037966294, 0.0015868889) (0.00037954602, 0.0015867312) (0.00037941421, 0.0015865858) (0.00037926879, 0.001586454) (0.00037911114, 0.0015863371) (0.00037894279, 0.0015862362) (0.00037876537, 0.0015861522) (0.00037858057, 0.0015860861) (0.00037839018, 0.0015860384) (0.00037819603, 0.0015860096) (0.000378, 0.001586) (0.000305, 0.001586) (0.000305, 0.001644) (0.000378, 0.001644), closed, covered)
  endcap_feed_in_start = rectangle(corner=(-0.001626, -1.1e-05, 0), x_size=6e-06, y_size=2.2e-05)
  endcap_feed_out_end = rectangle(corner=(0.00162, -1.1e-05, 0), x_size=6e-06, y_size=2.2e-05)
  ground_main_plane = rectangle(corner=(-0.00182, -0.000347, 0), x_size=0.00364, y_size=0.003468)
  main [silicon_eps11p45] = box(corner=(-0.00182, -0.000347, -0.0005), size=(0.00364, 0.003468, 0.0005))
  sample_holder [vacuum] = box(corner=(-0.00182, -0.000347, -0.00165), size=(0.00364, 0.003468, 0.00254))
  ground_main_plane.subtract(tap_cut_jr, pocket_cin, pocket_cj, lead_b_sub_cp, pocket_r_cj, cut_feed_out, cut_stub_r, lead_a_sub_cp, lead_b_sub_cin, tap_cut_jf, cut_res_open_run, open_to_ground_readout_open, lead_a_sub_cin, cut_feed_in, cut_feed_jf, lead_a_sub_cj, tap_cut_n0, cut_stub_f, cut_feed_mid, lead_b_sub_cj, cut_stub_p, endcap_feed_in_start, cut_res_tail, endcap_feed_out_end, pocket_cp, cut_filter_tail)
  Port_feed_in_start = rectangle(corner=(-0.001626, -5e-06, 0), x_size=6e-06, y_size=1e-05)
  voltage_line_Port_feed_in_start = polyline((-0.00162, 0, 0) (-0.001626, 0, 0))
  Port_feed_out_end = rectangle(corner=(0.00162, -5e-06, 0), x_size=6e-06, y_size=1e-05)
  voltage_line_Port_feed_out_end = polyline((0.00162, 0, 0) (0.001626, 0, 0))
  g_wb [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-3.05e-05 YPadPos=3e-05 ZPadPos=0 XDir=0 YDir=-1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_1 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=3.05e-05 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_2 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=3e-05 YPadPos=6.45e-05 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_3 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.0007664995 YPadPos=3e-05 ZPadPos=0 XDir=0 YDir=-1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_4 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-3e-05 YPadPos=0.0001760005 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_5 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.0014940625 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_6 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.0013021875 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_7 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.0011103125 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_8 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.0009184375 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_9 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000418125 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_10 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000259375 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_11 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000268125 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_12 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000444375 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_13 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000620625 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_14 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000796875 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_15 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000973125 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_16 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.001149375 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_17 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.001325625 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_18 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.001501875 YPadPos=-3e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_19 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=3e-05 YPadPos=0.000125 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_20 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=3e-05 YPadPos=0.000544 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_21 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=3e-05 YPadPos=0.000742 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_22 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=3e-05 YPadPos=0.00094 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_23 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=3e-05 YPadPos=0.001138 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_24 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=3e-05 YPadPos=0.001336 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_25 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00043 YPadPos=0.0018858333 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_26 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00043 YPadPos=0.0020675 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_27 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00043 YPadPos=0.0022491667 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_28 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00043 YPadPos=0.0024308333 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_29 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00043 YPadPos=0.0026125 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_30 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00043 YPadPos=0.0027941667 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_31 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=3e-05 YPadPos=0.00189275 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_32 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=3e-05 YPadPos=0.00208825 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_33 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00017930847 YPadPos=0.002315 ZPadPos=0 XDir=0 YDir=-1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_34 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.0003399254 YPadPos=0.002315 ZPadPos=0 XDir=0 YDir=-1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_35 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00054923387 YPadPos=0.00217 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_36 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00038461694 YPadPos=0.002025 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_37 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00028 YPadPos=0.00194 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_38 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00038461694 YPadPos=0.001855 ZPadPos=0 XDir=0 YDir=-1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_39 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00054923387 YPadPos=0.00171 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_40 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00038461694 YPadPos=0.001565 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_41 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00028 YPadPos=0.00148 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_42 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00038461694 YPadPos=0.001395 ZPadPos=0 XDir=0 YDir=-1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_43 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00054923387 YPadPos=0.0012155 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_44 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00037 YPadPos=0.0013398333 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_45 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00037 YPadPos=0.0011495 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_46 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00037 YPadPos=0.00095916667 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_47 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00058104423 YPadPos=0.000735 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_48 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.0007451327 YPadPos=0.000735 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_49 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00095617693 YPadPos=0.00088 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_50 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00078808847 YPadPos=0.001025 ZPadPos=0 XDir=0 YDir=-1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_51 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00068 YPadPos=0.00111 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_52 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00078808847 YPadPos=0.001195 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_53 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00095617693 YPadPos=0.00134 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_54 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00078808847 YPadPos=0.001485 ZPadPos=0 XDir=0 YDir=-1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_55 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00068 YPadPos=0.00157 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_56 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00078808847 YPadPos=0.001655 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_57 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00095617693 YPadPos=0.0018145 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=6e-05 h1=6e-05 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
boundaries and excitations:
  RLCBoundary_feed_in_start: Lumped RLC Objects=Port_feed_in_start CurrentLine{middle of Port_feed_in_start.edge(x at corner) -> middle of Port_feed_in_start.edge(x opposite corner)} RLC_Type=Parallel Resistance=50ohm
  RLCBoundary_feed_out_end: Lumped RLC Objects=Port_feed_out_end CurrentLine{middle of Port_feed_out_end.edge(x at corner) -> middle of Port_feed_out_end.edge(x opposite corner)} RLC_Type=Parallel Resistance=50ohm
  PerfE: Perfect E Objects=[lead_a_cin, lead_b_cin, lead_a_cp, lead_b_cp, trace_feed_in, trace_feed_mid, trace_feed_out, trace_stub_p, trace_stub_f, trace_stub_r, trace_feed_jf, trace_res_open_run, trace_filter_tail, trace_res_tail, plate_cin, frame_cin, tap_trace_n0, plate_cp, frame_cp, tap_trace_jf, tap_trace_jr, ground_main_plane]
mesh:
  port_mesh: LengthBased Objects=[Port_feed_in_start, Port_feed_out_end] MaxLength=7um
  cpw_line_mesh: LengthBased Objects=[lead_a_cin, lead_b_cin, trace_feed_in, trace_feed_mid, trace_feed_out, trace_stub_p, trace_stub_f, trace_stub_r, trace_feed_jf, trace_res_open_run, trace_filter_tail, trace_res_tail, plate_cin, frame_cin, tap_trace_n0, tap_trace_jf, tap_trace_jr] MaxLength=20um
  cap_mesh: LengthBased Objects=[lead_a_cp, lead_b_cp, plate_cp, frame_cp] MaxLength=9um
setups:
  Setup: HfssEigen MinimumFrequency=5.95GHz NumModes=2 MaxDeltaFreq=0.1 ConvergeOnRealFreq=true MaximumPasses=8 MinimumPasses=3 MinimumConvergedPasses=2 PercentRefinement=20 BasisOrder=1
source amplitudes:
  #-10:1: 1 0deg
  #-10:2: 0 0deg
reports:
  Freq. vs. pass: re(Mode(1)), re(Mode(2)) vs Pass on Setup : AdaptivePass

design P400nh_cpwwb_m11um_2253_hfss (HFSS, Eigenmode, model units mm)
geometry:
  lead_a_cin_path = polyline((-0.000740499, 0, 0) (-0.0007925, 0, 0))
  lead_a_cin = polyline((-0.000740499, -5e-06, 0) (-0.000740499, 5e-06, 0))
  lead_a_cin.sweep_along_path(lead_a_cin_path)
  lead_a_sub_cin_path = polyline((-0.000740499, 0, 0) (-0.0007925, 0, 0))
  lead_a_sub_cin = polyline((-0.000740499, -1.1e-05, 0) (-0.000740499, 1.1e-05, 0))
  lead_a_sub_cin.sweep_along_path(lead_a_sub_cin_path)
  lead_b_cin_path = polyline((-0.000639501, 0, 0) (-0.0005275, 0, 0))
  lead_b_cin = polyline((-0.000639501, 5e-06, 0) (-0.000639501, -5e-06, 0))
  lead_b_cin.sweep_along_path(lead_b_cin_path)
  lead_b_sub_cin_path = polyline((-0.000639501, 0, 0) (-0.0005275, 0, 0))
  lead_b_sub_cin = polyline((-0.000639501, 1.1e-05, 0) (-0.000639501, -1.1e-05, 0))
  lead_b_sub_cin.sweep_along_path(lead_b_sub_cin_path)
  lead_a_cp_path = polyline((0, 0.000202001, 0) (0, 0.00015, 0))
  lead_a_cp = polyline((5e-06, 0.000202001, 0) (-5e-06, 0.000202001, 0))
  lead_a_cp.sweep_along_path(lead_a_cp_path)
  lead_a_sub_cp_path = polyline((0, 0.000202001, 0) (0, 0.00015, 0))
  lead_a_sub_cp = polyline((1.1e-05, 0.000202001, 0) (-1.1e-05, 0.000202001, 0))
  lead_a_sub_cp.sweep_along_path(lead_a_sub_cp_path)
  lead_b_cp_path = polyline((0, 0.000302999, 0) (0, 0.000415, 0))
  lead_b_cp = polyline((-5e-06, 0.000302999, 0) (5e-06, 0.000302999, 0))
  lead_b_cp.sweep_along_path(lead_b_cp_path)
  lead_b_sub_cp_path = polyline((0, 0.000302999, 0) (0, 0.000415, 0))
  lead_b_sub_cp = polyline((-1.1e-05, 0.000302999, 0) (1.1e-05, 0.000302999, 0))
  lead_b_sub_cp.sweep_along_path(lead_b_sub_cp_path)
  trace_feed_in_path = polyline((-0.00162, 0, 0) (-0.0007925, 0, 0))
  trace_feed_in = polyline((-0.00162, 5e-06, 0) (-0.00162, -5e-06, 0))
  trace_feed_in.sweep_along_path(trace_feed_in_path)
  cut_feed_in_path = polyline((-0.00162, 0, 0) (-0.0007925, 0, 0))
  cut_feed_in = polyline((-0.00162, 1.1e-05, 0) (-0.00162, -1.1e-05, 0))
  cut_feed_in.sweep_along_path(cut_feed_in_path)
  trace_feed_mid_path = polyline((-0.0005275, 0, 0) (-0.00015, 0, 0))
  trace_feed_mid = polyline((-0.0005275, 5e-06, 0) (-0.0005275, -5e-06, 0))
  trace_feed_mid.sweep_along_path(trace_feed_mid_path)
  cut_feed_mid_path = polyline((-0.0005275, 0, 0) (-0.00015, 0, 0))
  cut_feed_mid = polyline((-0.0005275, 1.1e-05, 0) (-0.0005275, -1.1e-05, 0))
  cut_feed_mid.sweep_along_path(cut_feed_mid_path)
  trace_feed_out_path = polyline((0.00015, 0, 0) (0.00162, 0, 0))
  trace_feed_out = polyline((0.00015, 5e-06, 0) (0.00015, -5e-06, 0))
  trace_feed_out.sweep_along_path(trace_feed_out_path)
  cut_feed_out_path = polyline((0.00015, 0, 0) (0.00162, 0, 0))
  cut_feed_out = polyline((0.00015, 1.1e-05, 0) (0.00015, -1.1e-05, 0))
  cut_feed_out.sweep_along_path(cut_feed_out_path)
  trace_stub_p_path = polyline((0, 0.0001, 0) (0, 0.00015, 0))
  trace_stub_p = polyline((-5e-06, 0.0001, 0) (5e-06, 0.0001, 0))
  trace_stub_p.sweep_along_path(trace_stub_p_path)
  cut_stub_p_path = polyline((0, 0.0001, 0) (0, 0.00015, 0))
  cut_stub_p = polyline((-1.1e-05, 0.0001, 0) (1.1e-05, 0.0001, 0))
  cut_stub_p.sweep_along_path(cut_stub_p_path)
  lead_a_sub_cj_path = polyline((3.0001e-05, 0.001615, 0) (2e-05, 0.001615, 0))
  lead_a_sub_cj = polyline((3.0001e-05, 0.001604, 0) (3.0001e-05, 0.001626, 0))
  lead_a_sub_cj.sweep_along_path(lead_a_sub_cj_path)
  lead_b_sub_cj_path = polyline((0.000369999, 0.001615, 0) (0.00038, 0.001615, 0))
  lead_b_sub_cj = polyline((0.000369999, 0.001626, 0) (0.000369999, 0.001604, 0))
  lead_b_sub_cj.sweep_along_path(lead_b_sub_cj_path)
  trace_stub_f_path = polyline((0, 0.001615, 0) (2e-05, 0.001615, 0))
  trace_stub_f = polyline((0, 0.00162, 0) (0, 0.00161, 0))
  trace_stub_f.sweep_along_path(trace_stub_f_path)
  cut_stub_f_path = polyline((0, 0.001615, 0) (2e-05, 0.001615, 0))
  cut_stub_f = polyline((0, 0.001626, 0) (0, 0.001604, 0))
  cut_stub_f.sweep_along_path(cut_stub_f_path)
  trace_stub_r_path = polyline((0.00038, 0.001615, 0) (0.0004, 0.001615, 0))
  trace_stub_r = polyline((0.00038, 0.00162, 0) (0.00038, 0.00161, 0))
  trace_stub_r.sweep_along_path(trace_stub_r_path)
  cut_stub_r_path = polyline((0.00038, 0.001615, 0) (0.0004, 0.001615, 0))
  cut_stub_r = polyline((0.00038, 0.001626, 0) (0.00038, 0.001604, 0))
  cut_stub_r.sweep_along_path(cut_stub_r_path)
  trace_feed_jf_path = polyline((0, 0.000415, 0) (0, 0.001465, 0))
  trace_feed_jf = polyline((-5e-06, 0.000415, 0) (5e-06, 0.000415, 0))
  trace_feed_jf.sweep_along_path(trace_feed_jf_path)
  cut_feed_jf_path = polyline((0, 0.000415, 0) (0, 0.001465, 0))
  cut_feed_jf = polyline((-1.1e-05, 0.000415, 0) (1.1e-05, 0.000415, 0))
  cut_feed_jf.sweep_along_path(cut_feed_jf_path)
  trace_res_open_run_path = polyline((0.0004, 0.001765, 0) (0.0004, 0.002915, 0))
  trace_res_open_run = polyline((0.000395, 0.001765, 0) (0.000405, 0.001765, 0))
  trace_res_open_run.sweep_along_path(trace_res_open_run_path)
  cut_res_open_run_path = polyline((0.0004, 0.001765, 0) (0.0004, 0.002915, 0))
  cut_res_open_run = polyline((0.000389, 0.001765, 0) (0.000411, 0.001765, 0))
  cut_res_open_run.sweep_along_path(cut_res_open_run_path)
  trace_filter_tail_path = polyline(z=0, xy: (0, 0.001765) (0, 0.002285) (-0.00051923387, 0.002285) (-0.00051923387, 0.002055) (-0.00025, 0.002055) (-0.00025, 0.001825) (-0.00051923387, 0.001825) (-0.00051923387, 0.001595) (-0.00025, 0.001595) (-0.00025, 0.001365) (-0.00051923387, 0.001365) (-0.00051923387, 0.001135))
  trace_filter_tail_path.fillet(Vertices=trace_filter_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  trace_filter_tail = polyline((-5e-06, 0.001765, 0) (5e-06, 0.001765, 0))
  trace_filter_tail.sweep_along_path(trace_filter_tail_path)
  cut_filter_tail_path = polyline(z=0, xy: (0, 0.001765) (0, 0.002285) (-0.00051923387, 0.002285) (-0.00051923387, 0.002055) (-0.00025, 0.002055) (-0.00025, 0.001825) (-0.00051923387, 0.001825) (-0.00051923387, 0.001595) (-0.00025, 0.001595) (-0.00025, 0.001365) (-0.00051923387, 0.001365) (-0.00051923387, 0.001135))
  cut_filter_tail_path.fillet(Vertices=cut_filter_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  cut_filter_tail = polyline((-1.1e-05, 0.001765, 0) (1.1e-05, 0.001765, 0))
  cut_filter_tail.sweep_along_path(cut_filter_tail_path)
  trace_res_tail_path = polyline(z=0, xy: (0.0004, 0.001465) (0.0004, 0.000765) (0.00092617693, 0.000765) (0.00092617693, 0.000995) (0.00065, 0.000995) (0.00065, 0.001225) (0.00092617693, 0.001225) (0.00092617693, 0.001455) (0.00065, 0.001455) (0.00065, 0.001685) (0.00092617693, 0.001685) (0.00092617693, 0.001904))
  trace_res_tail_path.fillet(Vertices=trace_res_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  trace_res_tail = polyline((0.000405, 0.001465, 0) (0.000395, 0.001465, 0))
  trace_res_tail.sweep_along_path(trace_res_tail_path)
  cut_res_tail_path = polyline(z=0, xy: (0.0004, 0.001465) (0.0004, 0.000765) (0.00092617693, 0.000765) (0.00092617693, 0.000995) (0.00065, 0.000995) (0.00065, 0.001225) (0.00092617693, 0.001225) (0.00092617693, 0.001455) (0.00065, 0.001455) (0.00065, 0.001685) (0.00092617693, 0.001685) (0.00092617693, 0.001904))
  cut_res_tail_path.fillet(Vertices=cut_res_tail_path.vertex(2 of 12, 3 of 12, 4 of 12, 5 of 12, 6 of 12, 7 of 12, 8 of 12, 9 of 12, 10 of 12, 11 of 12) Radius=9.9e-05 Setback=0mm)
  cut_res_tail = polyline((0.000411, 0.001465, 0) (0.000389, 0.001465, 0))
  cut_res_tail.sweep_along_path(cut_res_tail_path)
  plate_cin = polyline(z=0, xy: (-0.0006725, -7e-05) (-0.00067328414, -6.9961478e-05) (-0.00067406072, -6.9846282e-05) (-0.00067482228, -6.9655523e-05) (-0.00067556147, -6.9391036e-05) (-0.00067627117, -6.905537e-05) (-0.00067694456, -6.8651757e-05) (-0.00067757515, -6.8184084e-05) (-0.00067815685, -6.7656854e-05) (-0.00067868408, -6.7075146e-05) (-0.00067915176, -6.6444562e-05) (-0.00067955537, -6.5771174e-05) (-0.00067989104, -6.5061467e-05) (-0.00068015552, -6.4322277e-05) (-0.00068034628, -6.3560723e-05) (-0.00068046148, -6.2784137e-05) (-0.0006805, -6.2e-05) (-0.0006805, 6.2e-05) (-0.00068046148, 6.2784137e-05) (-0.00068034628, 6.3560723e-05) (-0.00068015552, 6.4322277e-05) (-0.00067989104, 6.5061467e-05) (-0.00067955537, 6.5771174e-05) (-0.00067915176, 6.6444562e-05) (-0.00067868408, 6.7075146e-05) (-0.00067815685, 6.7656854e-05) (-0.00067757515, 6.8184084e-05) (-0.00067694456, 6.8651757e-05) (-0.00067627117, 6.905537e-05) (-0.00067556147, 6.9391036e-05) (-0.00067482228, 6.9655523e-05) (-0.00067406072, 6.9846282e-05) (-0.00067328414, 6.9961478e-05) (-0.0006725, 7e-05) (-0.0006475, 7e-05) (-0.00064671586, 6.9961478e-05) (-0.00064593928, 6.9846282e-05) (-0.00064517772, 6.9655523e-05) (-0.00064443853, 6.9391036e-05) (-0.00064372883, 6.905537e-05) (-0.00064305544, 6.8651757e-05) (-0.00064242485, 6.8184084e-05) (-0.00064184315, 6.7656854e-05) (-0.00064131592, 6.7075146e-05) (-0.00064084824, 6.6444562e-05) (-0.00064044463, 6.5771174e-05) (-0.00064010896, 6.5061467e-05) (-0.00063984448, 6.4322277e-05) (-0.00063965372, 6.3560723e-05) (-0.00063953852, 6.2784137e-05) (-0.0006395, 6.2e-05) (-0.0006395, -6.2e-05) (-0.00063953852, -6.2784137e-05) (-0.00063965372, -6.3560723e-05) (-0.00063984448, -6.4322277e-05) (-0.00064010896, -6.5061467e-05) (-0.00064044463, -6.5771174e-05) (-0.00064084824, -6.6444562e-05) (-0.00064131592, -6.7075146e-05) (-0.00064184315, -6.7656854e-05) (-0.00064242485, -6.8184084e-05) (-0.00064305544, -6.8651757e-05) (-0.00064372883, -6.905537e-05) (-0.00064443853, -6.9391036e-05) (-0.00064517772, -6.9655523e-05) (-0.00064593928, -6.9846282e-05) (-0.00064671586, -6.9961478e-05) (-0.0006475, -7e-05) (-0.0006725, -7e-05), closed, covered)
  frame_cin = polyline(z=0, xy: (-0.0006885, -7e-05) (-0.00068846148, -7.0784137e-05) (-0.00068834628, -7.1560723e-05) (-0.00068815552, -7.2322277e-05) (-0.00068789104, -7.3061467e-05) (-0.00068755537, -7.3771174e-05) (-0.00068715176, -7.4444562e-05) (-0.00068668408, -7.5075146e-05) (-0.00068615685, -7.5656854e-05) (-0.00068557515, -7.6184084e-05) (-0.00068494456, -7.6651757e-05) (-0.00068427117, -7.705537e-05) (-0.00068356147, -7.7391036e-05) (-0.00068282228, -7.7655523e-05) (-0.00068206072, -7.7846282e-05) (-0.00068128414, -7.7961478e-05) (-0.0006805, -7.8e-05) (-0.0006395, -7.8e-05) (-0.00063871586, -7.7961478e-05) (-0.00063793928, -7.7846282e-05) (-0.00063717772, -7.7655523e-05) (-0.00063643853, -7.7391036e-05) (-0.00063572883, -7.705537e-05) (-0.00063505544, -7.6651757e-05) (-0.00063442485, -7.6184084e-05) (-0.00063384315, -7.5656854e-05) (-0.00063331592, -7.5075146e-05) (-0.00063284824, -7.4444562e-05) (-0.00063244463, -7.3771174e-05) (-0.00063210896, -7.3061467e-05) (-0.00063184448, -7.2322277e-05) (-0.00063165372, -7.1560723e-05) (-0.00063153852, -7.0784137e-05) (-0.0006315, -7e-05) (-0.0006315, -1.909818e-05) (-0.00063149518, -1.8901939e-05) (-0.00063147111, -1.8412015e-05) (-0.00063143266, -1.80216e-05) (-0.0006313751, -1.7633541e-05) (-0.00063129856, -1.7248774e-05) (-0.00063120324, -1.6868226e-05) (-0.00063108936, -1.6492814e-05) (-0.0006309572, -1.6123441e-05) (-0.00063080707, -1.5760999e-05) (-0.00063063934, -1.540636e-05) (-0.00063045441, -1.5060378e-05) (-0.00063025272, -1.4723887e-05) (-0.00063003477, -1.4397697e-05) (-0.00062980107, -1.4082595e-05) (-0.0006295522, -1.3779339e-05) (-0.00062928874, -1.348866e-05) (-0.00062901134, -1.3211259e-05) (-0.00062872066, -1.2947803e-05) (-0.00062841741, -1.2698928e-05) (-0.0006281023, -1.2465232e-05) (-0.00062777611, -1.2247279e-05) (-0.00062743962, -1.2045594e-05) (-0.00062709364, -1.1860663e-05) (-0.000626739, -1.1692931e-05) (-0.00062637656, -1.1542802e-05) (-0.00062600719, -1.1410639e-05) (-0.00062563177, -1.1296759e-05) (-0.00062525123, -1.1201436e-05) (-0.00062486646, -1.1124902e-05) (-0.0006244784, -1.1067338e-05) (-0.00062408799, -1.1028886e-05) (-0.00062359806, -1.1004817e-05) (-0.00062340182, -1.1e-05) (-0.00057559818, -1.1e-05) (-0.00057540194, -1.1004817e-05) (-0.00057491201, -1.1028886e-05) (-0.0005745216, -1.1067338e-05) (-0.00057413354, -1.1124902e-05) (-0.00057374877, -1.1201436e-05) (-0.00057336823, -1.1296759e-05) (-0.00057299281, -1.1410639e-05) (-0.00057262344, -1.1542802e-05) (-0.000572261, -1.1692931e-05) (-0.00057190636, -1.1860663e-05) (-0.00057156038, -1.2045594e-05) (-0.00057122389, -1.2247279e-05) (-0.0005708977, -1.2465232e-05) (-0.0005705826, -1.2698928e-05) (-0.00057027934, -1.2947803e-05) (-0.00056998866, -1.3211259e-05) (-0.00056971126, -1.348866e-05) (-0.0005694478, -1.3779339e-05) (-0.00056919893, -1.4082595e-05) (-0.00056896523, -1.4397697e-05) (-0.00056874728, -1.4723887e-05) (-0.00056854559, -1.5060378e-05) (-0.00056836066, -1.540636e-05) (-0.00056819293, -1.5760999e-05) (-0.0005680428, -1.6123441e-05) (-0.00056791064, -1.6492814e-05) (-0.00056779676, -1.6868226e-05) (-0.00056770144, -1.7248774e-05) (-0.0005676249, -1.7633541e-05) (-0.00056756734, -1.80216e-05) (-0.00056752889, -1.8412015e-05) (-0.00056750482, -1.8901939e-05) (-0.0005675, -1.909818e-05) (-0.0005675, -0.00012690182) (-0.00056750482, -0.00012709806) (-0.00056752889, -0.00012758798) (-0.00056756734, -0.0001279784) (-0.0005676249, -0.00012836646) (-0.00056770144, -0.00012875123) (-0.00056779676, -0.00012913177) (-0.00056791064, -0.00012950719) (-0.0005680428, -0.00012987656) (-0.00056819293, -0.000130239) (-0.00056836066, -0.00013059364) (-0.00056854559, -0.00013093962) (-0.00056874728, -0.00013127611) (-0.00056896523, -0.0001316023) (-0.00056919893, -0.00013191741) (-0.0005694478, -0.00013222066) (-0.00056971126, -0.00013251134) (-0.00056998866, -0.00013278874) (-0.00057027934, -0.0001330522) (-0.0005705826, -0.00013330107) (-0.0005708977, -0.00013353477) (-0.00057122389, -0.00013375272) (-0.00057156038, -0.00013395441) (-0.00057190636, -0.00013413934) (-0.000572261, -0.00013430707) (-0.00057262344, -0.0001344572) (-0.00057299281, -0.00013458936) (-0.00057336823, -0.00013470324) (-0.00057374877, -0.00013479856) (-0.00057413354, -0.0001348751) (-0.0005745216, -0.00013493266) (-0.00057491201, -0.00013497111) (-0.00057540194, -0.00013499518) (-0.00057559818, -0.000135) (-0.00073240182, -0.000135) (-0.00073259806, -0.00013499518) (-0.00073308798, -0.00013497111) (-0.0007334784, -0.00013493266) (-0.00073386646, -0.0001348751) (-0.00073425123, -0.00013479856) (-0.00073463177, -0.00013470324) (-0.00073500719, -0.00013458936) (-0.00073537656, -0.0001344572) (-0.000735739, -0.00013430707) (-0.00073609364, -0.00013413934) (-0.00073643962, -0.00013395441) (-0.00073677611, -0.00013375272) (-0.0007371023, -0.00013353477) (-0.0007374174, -0.00013330107) (-0.00073772066, -0.0001330522) (-0.00073801134, -0.00013278874) (-0.00073828874, -0.00013251134) (-0.0007385522, -0.00013222066) (-0.00073880107, -0.00013191741) (-0.00073903477, -0.0001316023) (-0.00073925272, -0.00013127611) (-0.00073945441, -0.00013093962) (-0.00073963934, -0.00013059364) (-0.00073980707, -0.000130239) (-0.0007399572, -0.00012987656) (-0.00074008936, -0.00012950719) (-0.00074020324, -0.00012913177) (-0.00074029856, -0.00012875123) (-0.0007403751, -0.00012836646) (-0.00074043266, -0.0001279784) (-0.00074047111, -0.00012758798) (-0.00074049518, -0.00012709806) (-0.0007405, -0.00012690182) (-0.0007405, 0.00012690182) (-0.00074049518, 0.00012709806) (-0.00074047111, 0.00012758798) (-0.00074043266, 0.0001279784) (-0.0007403751, 0.00012836646) (-0.00074029856, 0.00012875123) (-0.00074020324, 0.00012913177) (-0.00074008936, 0.00012950719) (-0.0007399572, 0.00012987656) (-0.00073980707, 0.000130239) (-0.00073963934, 0.00013059364) (-0.00073945441, 0.00013093962) (-0.00073925272, 0.00013127611) (-0.00073903477, 0.0001316023) (-0.00073880107, 0.00013191741) (-0.0007385522, 0.00013222066) (-0.00073828874, 0.00013251134) (-0.00073801134, 0.00013278874) (-0.00073772066, 0.0001330522) (-0.0007374174, 0.00013330107) (-0.0007371023, 0.00013353477) (-0.00073677611, 0.00013375272) (-0.00073643962, 0.00013395441) (-0.00073609364, 0.00013413934) (-0.000735739, 0.00013430707) (-0.00073537656, 0.0001344572) (-0.00073500719, 0.00013458936) (-0.00073463177, 0.00013470324) (-0.00073425123, 0.00013479856) (-0.00073386646, 0.0001348751) (-0.0007334784, 0.00013493266) (-0.00073308798, 0.00013497111) (-0.00073259806, 0.00013499518) (-0.00073240182, 0.000135) (-0.00057559818, 0.000135) (-0.00057540194, 0.00013499518) (-0.00057491201, 0.00013497111) (-0.0005745216, 0.00013493266) (-0.00057413354, 0.0001348751) (-0.00057374877, 0.00013479856) (-0.00057336823, 0.00013470324) (-0.00057299281, 0.00013458936) (-0.00057262344, 0.0001344572) (-0.000572261, 0.00013430707) (-0.00057190636, 0.00013413934) (-0.00057156038, 0.00013395441) (-0.00057122389, 0.00013375272) (-0.0005708977, 0.00013353477) (-0.0005705826, 0.00013330107) (-0.00057027934, 0.0001330522) (-0.00056998866, 0.00013278874) (-0.00056971126, 0.00013251134) (-0.0005694478, 0.00013222066) (-0.00056919893, 0.00013191741) (-0.00056896523, 0.0001316023) (-0.00056874728, 0.00013127611) (-0.00056854559, 0.00013093962) (-0.00056836066, 0.00013059364) (-0.00056819293, 0.000130239) (-0.0005680428, 0.00012987656) (-0.00056791064, 0.00012950719) (-0.00056779676, 0.00012913177) (-0.00056770144, 0.00012875123) (-0.0005676249, 0.00012836646) (-0.00056756734, 0.0001279784) (-0.00056752889, 0.00012758798) (-0.00056750482, 0.00012709806) (-0.0005675, 0.00012690182) (-0.0005675, 1.909818e-05) (-0.00056750482, 1.8901939e-05) (-0.00056752889, 1.8412015e-05) (-0.00056756734, 1.80216e-05) (-0.0005676249, 1.7633541e-05) (-0.00056770144, 1.7248774e-05) (-0.00056779676, 1.6868226e-05) (-0.00056791064, 1.6492814e-05) (-0.0005680428, 1.6123441e-05) (-0.00056819293, 1.5760999e-05) (-0.00056836066, 1.540636e-05) (-0.00056854559, 1.5060378e-05) (-0.00056874728, 1.4723887e-05) (-0.00056896523, 1.4397697e-05) (-0.00056919893, 1.4082595e-05) (-0.0005694478, 1.3779339e-05) (-0.00056971126, 1.348866e-05) (-0.00056998866, 1.3211259e-05) (-0.00057027934, 1.2947803e-05) (-0.0005705826, 1.2698928e-05) (-0.0005708977, 1.2465232e-05) (-0.00057122389, 1.2247279e-05) (-0.00057156038, 1.2045594e-05) (-0.00057190636, 1.1860663e-05) (-0.000572261, 1.1692931e-05) (-0.00057262344, 1.1542802e-05) (-0.00057299281, 1.1410639e-05) (-0.00057336823, 1.1296759e-05) (-0.00057374877, 1.1201436e-05) (-0.00057413354, 1.1124902e-05) (-0.0005745216, 1.1067338e-05) (-0.00057491201, 1.1028886e-05) (-0.00057540194, 1.1004817e-05) (-0.00057559818, 1.1e-05) (-0.00062340182, 1.1e-05) (-0.00062359806, 1.1004817e-05) (-0.00062408799, 1.1028886e-05) (-0.0006244784, 1.1067338e-05) (-0.00062486646, 1.1124902e-05) (-0.00062525123, 1.1201436e-05) (-0.00062563177, 1.1296759e-05) (-0.00062600719, 1.1410639e-05) (-0.00062637656, 1.1542802e-05) (-0.000626739, 1.1692931e-05) (-0.00062709364, 1.1860663e-05) (-0.00062743962, 1.2045594e-05) (-0.00062777611, 1.2247279e-05) (-0.0006281023, 1.2465232e-05) (-0.00062841741, 1.2698928e-05) (-0.00062872066, 1.2947803e-05) (-0.00062901134, 1.3211259e-05) (-0.00062928874, 1.348866e-05) (-0.0006295522, 1.3779339e-05) (-0.00062980107, 1.4082595e-05) (-0.00063003477, 1.4397697e-05) (-0.00063025272, 1.4723887e-05) (-0.00063045441, 1.5060378e-05) (-0.00063063934, 1.540636e-05) (-0.00063080707, 1.5760999e-05) (-0.0006309572, 1.6123441e-05) (-0.00063108936, 1.6492814e-05) (-0.00063120324, 1.6868226e-05)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, closed, covered)
  pocket_cin = polyline(z=0, xy: (-0.0007525, -0.000135) (-0.0007525, 0.000135) (-0.00075244222, 0.00013617621) (-0.00075226942, 0.00013734108) (-0.00075198328, 0.00013848342) (-0.00075158655, 0.0001395922) (-0.00075108306, 0.00014065676) (-0.00075047764, 0.00014166684) (-0.00074977613, 0.00014261272) (-0.00074898528, 0.00014348528) (-0.00074811272, 0.00014427613) (-0.00074716684, 0.00014497764) (-0.00074615676, 0.00014558305) (-0.0007450922, 0.00014608655) (-0.00074398342, 0.00014648328) (-0.00074284108, 0.00014676942) (-0.00074167621, 0.00014694222) (-0.0007405, 0.000147) (-0.0005675, 0.000147) (-0.00056632379, 0.00014694222) (-0.00056515892, 0.00014676942) (-0.00056401658, 0.00014648328) (-0.0005629078, 0.00014608655) (-0.00056184324, 0.00014558305) (-0.00056083316, 0.00014497764) (-0.00055988728, 0.00014427613) (-0.00055901472, 0.00014348528) (-0.00055822388, 0.00014261272) (-0.00055752237, 0.00014166684) (-0.00055691694, 0.00014065676) (-0.00055641345, 0.0001395922) (-0.00055601672, 0.00013848342) (-0.00055573058, 0.00013734108) (-0.00055555778, 0.00013617621) (-0.0005555, 0.000135) (-0.0005555, -0.000135) (-0.00055555778, -0.00013617621) (-0.00055573058, -0.00013734108) (-0.00055601672, -0.00013848342) (-0.00055641345, -0.0001395922) (-0.00055691694, -0.00014065676) (-0.00055752237, -0.00014166684) (-0.00055822388, -0.00014261272) (-0.00055901472, -0.00014348528) (-0.00055988728, -0.00014427613) (-0.00056083316, -0.00014497764) (-0.00056184324, -0.00014558305) (-0.0005629078, -0.00014608655) (-0.00056401658, -0.00014648328) (-0.00056515892, -0.00014676942) (-0.00056632379, -0.00014694222) (-0.0005675, -0.000147) (-0.0007405, -0.000147) (-0.00074167621, -0.00014694222) (-0.00074284108, -0.00014676942) (-0.00074398342, -0.00014648328) (-0.0007450922, -0.00014608655) (-0.00074615676, -0.00014558305) (-0.00074716684, -0.00014497764) (-0.00074811272, -0.00014427613) (-0.00074898528, -0.00014348528) (-0.00074977613, -0.00014261272) (-0.00075047764, -0.00014166684) (-0.00075108306, -0.00014065676) (-0.00075158655, -0.0001395922) (-0.00075198328, -0.00013848342) (-0.00075226942, -0.00013734108) (-0.00075244222, -0.00013617621) (-0.0007525, -0.000135), closed, covered)
  tap_trace_n0 = polyline(z=0, xy: (0.00015, -5e-06) (-0.00015, -5e-06) (-0.00015, 5e-06) (-5e-06, 5e-06) (-5e-06, 0.0001) (5e-06, 0.0001) (5e-06, 5e-06) (0.00015, 5e-06) (0.00015, -5e-06), closed, covered)
  tap_cut_n0 = polyline(z=0, xy: (0.00015, -1.1e-05) (-0.00015, -1.1e-05) (-0.00015, 1.1e-05) (-1.1e-05, 1.1e-05) (-1.1e-05, 0.0001) (1.1e-05, 0.0001) (1.1e-05, 1.1e-05) (0.00015, 1.1e-05) (0.00015, -1.1e-05), closed, covered)
  plate_cp = polyline(z=0, xy: (7e-05, 0.00027) (6.9961478e-05, 0.00026921586) (6.9846282e-05, 0.00026843928) (6.9655523e-05, 0.00026767772) (6.9391036e-05, 0.00026693853) (6.905537e-05, 0.00026622883) (6.8651757e-05, 0.00026555544) (6.8184084e-05, 0.00026492485) (6.7656854e-05, 0.00026434315) (6.7075146e-05, 0.00026381592) (6.6444562e-05, 0.00026334824) (6.5771174e-05, 0.00026294463) (6.5061467e-05, 0.00026260896) (6.4322277e-05, 0.00026234448) (6.3560723e-05, 0.00026215372) (6.2784137e-05, 0.00026203852) (6.2e-05, 0.000262) (-6.2e-05, 0.000262) (-6.2784137e-05, 0.00026203852) (-6.3560723e-05, 0.00026215372) (-6.4322277e-05, 0.00026234448) (-6.5061467e-05, 0.00026260896) (-6.5771174e-05, 0.00026294463) (-6.6444562e-05, 0.00026334824) (-6.7075146e-05, 0.00026381592) (-6.7656854e-05, 0.00026434315) (-6.8184084e-05, 0.00026492485) (-6.8651757e-05, 0.00026555544) (-6.905537e-05, 0.00026622883) (-6.9391036e-05, 0.00026693853) (-6.9655523e-05, 0.00026767772) (-6.9846282e-05, 0.00026843928) (-6.9961478e-05, 0.00026921586) (-7e-05, 0.00027) (-7e-05, 0.000295) (-6.9961478e-05, 0.00029578414) (-6.9846282e-05, 0.00029656072) (-6.9655523e-05, 0.00029732228) (-6.9391036e-05, 0.00029806147) (-6.905537e-05, 0.00029877117) (-6.8651757e-05, 0.00029944456) (-6.8184084e-05, 0.00030007515) (-6.7656854e-05, 0.00030065685) (-6.7075146e-05, 0.00030118408) (-6.6444562e-05, 0.00030165176) (-6.5771174e-05, 0.00030205537) (-6.5061467e-05, 0.00030239104) (-6.4322277e-05, 0.00030265552) (-6.3560723e-05, 0.00030284628) (-6.2784137e-05, 0.00030296148) (-6.2e-05, 0.000303) (6.2e-05, 0.000303) (6.2784137e-05, 0.00030296148) (6.3560723e-05, 0.00030284628) (6.4322277e-05, 0.00030265552) (6.5061467e-05, 0.00030239104) (6.5771174e-05, 0.00030205537) (6.6444562e-05, 0.00030165176) (6.7075146e-05, 0.00030118408) (6.7656854e-05, 0.00030065685) (6.8184084e-05, 0.00030007515) (6.8651757e-05, 0.00029944456) (6.905537e-05, 0.00029877117) (6.9391036e-05, 0.00029806147) (6.9655523e-05, 0.00029732228) (6.9846282e-05, 0.00029656072) (6.9961478e-05, 0.00029578414) (7e-05, 0.000295) (7e-05, 0.00027), closed, covered)
  frame_cp = polyline(z=0, xy: (7e-05, 0.000254) (7.0784137e-05, 0.00025403852) (7.1560723e-05, 0.00025415372) (7.2322277e-05, 0.00025434448) (7.3061467e-05, 0.00025460896) (7.3771174e-05, 0.00025494463) (7.4444562e-05, 0.00025534824) (7.5075146e-05, 0.00025581592) (7.5656854e-05, 0.00025634315) (7.6184084e-05, 0.00025692485) (7.6651757e-05, 0.00025755544) (7.705537e-05, 0.00025822883) (7.7391036e-05, 0.00025893853) (7.7655523e-05, 0.00025967772) (7.7846282e-05, 0.00026043928) (7.7961478e-05, 0.00026121586) (7.8e-05, 0.000262) (7.8e-05, 0.000303) (7.7961478e-05, 0.00030378414) (7.7846282e-05, 0.00030456072) (7.7655523e-05, 0.00030532228) (7.7391036e-05, 0.00030606147) (7.705537e-05, 0.00030677117) (7.6651757e-05, 0.00030744456) (7.6184084e-05, 0.00030807515) (7.5656854e-05, 0.00030865685) (7.5075146e-05, 0.00030918408) (7.4444562e-05, 0.00030965176) (7.3771174e-05, 0.00031005537) (7.3061467e-05, 0.00031039104) (7.2322277e-05, 0.00031065552) (7.1560723e-05, 0.00031084628) (7.0784137e-05, 0.00031096148) (7e-05, 0.000311) (1.909818e-05, 0.000311) (1.8901939e-05, 0.00031100482) (1.8412015e-05, 0.00031102889) (1.80216e-05, 0.00031106734) (1.7633541e-05, 0.0003111249) (1.7248774e-05, 0.00031120144) (1.6868226e-05, 0.00031129676) (1.6492814e-05, 0.00031141064) (1.6123441e-05, 0.0003115428) (1.5760999e-05, 0.00031169293) (1.540636e-05, 0.00031186066) (1.5060378e-05, 0.00031204559) (1.4723887e-05, 0.00031224728) (1.4397697e-05, 0.00031246523) (1.4082595e-05, 0.00031269893) (1.3779339e-05, 0.0003129478) (1.348866e-05, 0.00031321126) (1.3211259e-05, 0.00031348866) (1.2947803e-05, 0.00031377934) (1.2698928e-05, 0.00031408259) (1.2465232e-05, 0.0003143977) (1.2247279e-05, 0.00031472389) (1.2045594e-05, 0.00031506038) (1.1860663e-05, 0.00031540636) (1.1692931e-05, 0.000315761) (1.1542802e-05, 0.00031612344) (1.1410639e-05, 0.00031649281) (1.1296759e-05, 0.00031686823) (1.1201436e-05, 0.00031724877) (1.1124902e-05, 0.00031763354) (1.1067338e-05, 0.0003180216) (1.1028886e-05, 0.00031841202) (1.1004817e-05, 0.00031890194) (1.1e-05, 0.00031909818) (1.1e-05, 0.00036690182) (1.1004817e-05, 0.00036709806) (1.1028886e-05, 0.00036758799) (1.1067338e-05, 0.0003679784) (1.1124902e-05, 0.00036836646) (1.1201436e-05, 0.00036875123) (1.1296759e-05, 0.00036913177) (1.1410639e-05, 0.00036950719) (1.1542802e-05, 0.00036987656) (1.1692931e-05, 0.000370239) (1.1860663e-05, 0.00037059364) (1.2045594e-05, 0.00037093962) (1.2247279e-05, 0.00037127611) (1.2465232e-05, 0.0003716023) (1.2698928e-05, 0.0003719174) (1.2947803e-05, 0.00037222066) (1.3211259e-05, 0.00037251134) (1.348866e-05, 0.00037278874) (1.3779339e-05, 0.0003730522) (1.4082595e-05, 0.00037330107) (1.4397697e-05, 0.00037353477) (1.4723887e-05, 0.00037375272) (1.5060378e-05, 0.00037395441) (1.540636e-05, 0.00037413934) (1.5760999e-05, 0.00037430707) (1.6123441e-05, 0.0003744572) (1.6492814e-05, 0.00037458936) (1.6868226e-05, 0.00037470324) (1.7248774e-05, 0.00037479856) (1.7633541e-05, 0.0003748751) (1.80216e-05, 0.00037493266) (1.8412015e-05, 0.00037497111) (1.8901939e-05, 0.00037499518) (1.909818e-05, 0.000375) (0.00012690182, 0.000375) (0.00012709806, 0.00037499518) (0.00012758798, 0.00037497111) (0.0001279784, 0.00037493266) (0.00012836646, 0.0003748751) (0.00012875123, 0.00037479856) (0.00012913177, 0.00037470324) (0.00012950719, 0.00037458936) (0.00012987656, 0.0003744572) (0.000130239, 0.00037430707) (0.00013059364, 0.00037413934) (0.00013093962, 0.00037395441) (0.00013127611, 0.00037375272) (0.0001316023, 0.00037353477) (0.00013191741, 0.00037330107) (0.00013222066, 0.0003730522) (0.00013251134, 0.00037278874) (0.00013278874, 0.00037251134) (0.0001330522, 0.00037222066) (0.00013330107, 0.0003719174) (0.00013353477, 0.0003716023) (0.00013375272, 0.00037127611) (0.00013395441, 0.00037093962) (0.00013413934, 0.00037059364) (0.00013430707, 0.000370239) (0.0001344572, 0.00036987656) (0.00013458936, 0.00036950719) (0.00013470324, 0.00036913177) (0.00013479856, 0.00036875123) (0.0001348751, 0.00036836646) (0.00013493266, 0.0003679784) (0.00013497111, 0.00036758799) (0.00013499518, 0.00036709806) (0.000135, 0.00036690182) (0.000135, 0.00021009818) (0.00013499518, 0.00020990194) (0.00013497111, 0.00020941201) (0.00013493266, 0.0002090216) (0.0001348751, 0.00020863354) (0.00013479856, 0.00020824877) (0.00013470324, 0.00020786823) (0.00013458936, 0.00020749281) (0.0001344572, 0.00020712344) (0.00013430707, 0.000206761) (0.00013413934, 0.00020640636) (0.00013395441, 0.00020606038) (0.00013375272, 0.00020572389) (0.00013353477, 0.0002053977) (0.00013330107, 0.00020508259) (0.0001330522, 0.00020477934) (0.00013278874, 0.00020448866) (0.00013251134, 0.00020421126) (0.00013222066, 0.0002039478) (0.00013191741, 0.00020369893) (0.0001316023, 0.00020346523) (0.00013127611, 0.00020324728) (0.00013093962, 0.00020304559) (0.00013059364, 0.00020286066) (0.000130239, 0.00020269293) (0.00012987656, 0.0002025428) (0.00012950719, 0.00020241064) (0.00012913177, 0.00020229676) (0.00012875123, 0.00020220144) (0.00012836646, 0.0002021249) (0.0001279784, 0.00020206734) (0.00012758798, 0.00020202889) (0.00012709806, 0.00020200482) (0.00012690182, 0.000202) (-0.00012690182, 0.000202) (-0.00012709806, 0.00020200482) (-0.00012758798, 0.00020202889) (-0.0001279784, 0.00020206734) (-0.00012836646, 0.0002021249) (-0.00012875123, 0.00020220144) (-0.00012913177, 0.00020229676) (-0.00012950719, 0.00020241064) (-0.00012987656, 0.0002025428) (-0.000130239, 0.00020269293) (-0.00013059364, 0.00020286066) (-0.00013093962, 0.00020304559) (-0.00013127611, 0.00020324728) (-0.0001316023, 0.00020346523) (-0.00013191741, 0.00020369893) (-0.00013222066, 0.0002039478) (-0.00013251134, 0.00020421126) (-0.00013278874, 0.00020448866) (-0.0001330522, 0.00020477934) (-0.00013330107, 0.00020508259) (-0.00013353477, 0.0002053977) (-0.00013375272, 0.00020572389) (-0.00013395441, 0.00020606038) (-0.00013413934, 0.00020640636) (-0.00013430707, 0.000206761) (-0.0001344572, 0.00020712344) (-0.00013458936, 0.00020749281) (-0.00013470324, 0.00020786823) (-0.00013479856, 0.00020824877) (-0.0001348751, 0.00020863354) (-0.00013493266, 0.0002090216) (-0.00013497111, 0.00020941201) (-0.00013499518, 0.00020990194) (-0.000135, 0.00021009818) (-0.000135, 0.00036690182) (-0.00013499518, 0.00036709806) (-0.00013497111, 0.00036758799) (-0.00013493266, 0.0003679784) (-0.0001348751, 0.00036836646) (-0.00013479856, 0.00036875123) (-0.00013470324, 0.00036913177) (-0.00013458936, 0.00036950719) (-0.0001344572, 0.00036987656) (-0.00013430707, 0.000370239) (-0.00013413934, 0.00037059364) (-0.00013395441, 0.00037093962) (-0.00013375272, 0.00037127611) (-0.00013353477, 0.0003716023) (-0.00013330107, 0.0003719174) (-0.0001330522, 0.00037222066) (-0.00013278874, 0.00037251134) (-0.00013251134, 0.00037278874) (-0.00013222066, 0.0003730522) (-0.00013191741, 0.00037330107) (-0.0001316023, 0.00037353477) (-0.00013127611, 0.00037375272) (-0.00013093962, 0.00037395441) (-0.00013059364, 0.00037413934) (-0.000130239, 0.00037430707) (-0.00012987656, 0.0003744572) (-0.00012950719, 0.00037458936) (-0.00012913177, 0.00037470324) (-0.00012875123, 0.00037479856) (-0.00012836646, 0.000374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
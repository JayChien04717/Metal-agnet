# Ansys Electronics Desktop project, version 2021.2
materials:
  vacuum: permittivity=1
  pec: conductivity=1e+30
  silicon: permittivity=11.9
  copper: permeability=0.999991 conductivity=58000000
  silicon_eps11p45: permittivity=11.45

design v6_full_eig_hfss (HFSS, Eigenmode, model units mm)
geometry:
  lead_a_cp_ch3_path = polyline((0, -0.000362999, 0) (0, -0.000415, 0))
  lead_a_cp_ch3 = polyline((5e-06, -0.000362999, 0) (-5e-06, -0.000362999, 0))
  lead_a_cp_ch3.sweep_along_path(lead_a_cp_ch3_path)
  lead_a_sub_cp_ch3_path = polyline((0, -0.000362999, 0) (0, -0.000415, 0))
  lead_a_sub_cp_ch3 = polyline((1.1e-05, -0.000362999, 0) (-1.1e-05, -0.000362999, 0))
  lead_a_sub_cp_ch3.sweep_along_path(lead_a_sub_cp_ch3_path)
  lead_b_cp_ch3_path = polyline((0, -0.000262001, 0) (0, -0.00015, 0))
  lead_b_cp_ch3 = polyline((-5e-06, -0.000262001, 0) (5e-06, -0.000262001, 0))
  lead_b_cp_ch3.sweep_along_path(lead_b_cp_ch3_path)
  lead_b_sub_cp_ch3_path = polyline((0, -0.000262001, 0) (0, -0.00015, 0))
  lead_b_sub_cp_ch3 = polyline((-1.1e-05, -0.000262001, 0) (1.1e-05, -0.000262001, 0))
  lead_b_sub_cp_ch3.sweep_along_path(lead_b_sub_cp_ch3_path)
  trace_stub_p_ch3_path = polyline((0, -0.0001, 0) (0, -0.00015, 0))
  trace_stub_p_ch3 = polyline((5e-06, -0.0001, 0) (-5e-06, -0.0001, 0))
  trace_stub_p_ch3.sweep_along_path(trace_stub_p_ch3_path)
  cut_stub_p_ch3_path = polyline((0, -0.0001, 0) (0, -0.00015, 0))
  cut_stub_p_ch3 = polyline((1.1e-05, -0.0001, 0) (-1.1e-05, -0.0001, 0))
  cut_stub_p_ch3.sweep_along_path(cut_stub_p_ch3_path)
  trace_feed_jf_ch3_path = polyline((0, -0.000415, 0) (0, -0.001465, 0))
  trace_feed_jf_ch3 = polyline((5e-06, -0.000415, 0) (-5e-06, -0.000415, 0))
  trace_feed_jf_ch3.sweep_along_path(trace_feed_jf_ch3_path)
  cut_feed_jf_ch3_path = polyline((0, -0.000415, 0) (0, -0.001465, 0))
  cut_feed_jf_ch3 = polyline((1.1e-05, -0.000415, 0) (-1.1e-05, -0.000415, 0))
  cut_feed_jf_ch3.sweep_along_path(cut_feed_jf_ch3_path)
  lead_a_cj_ch3_path = polyline((6.5501e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  lead_a_cj_ch3 = polyline((6.5501e-05, -0.00162, 0) (6.5501e-05, -0.00161, 0))
  lead_a_cj_ch3.sweep_along_path(lead_a_cj_ch3_path)
  lead_a_sub_cj_ch3_path = polyline((6.5501e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  lead_a_sub_cj_ch3 = polyline((6.5501e-05, -0.001626, 0) (6.5501e-05, -0.001604, 0))
  lead_a_sub_cj_ch3.sweep_along_path(lead_a_sub_cj_ch3_path)
  lead_b_cj_ch3_path = polyline((0.000134499, -0.001615, 0) (0.0001445, -0.001615, 0))
  lead_b_cj_ch3 = polyline((0.000134499, -0.00161, 0) (0.000134499, -0.00162, 0))
  lead_b_cj_ch3.sweep_along_path(lead_b_cj_ch3_path)
  lead_b_sub_cj_ch3_path = polyline((0.000134499, -0.001615, 0) (0.0001445, -0.001615, 0))
  lead_b_sub_cj_ch3 = polyline((0.000134499, -0.001604, 0) (0.000134499, -0.001626, 0))
  lead_b_sub_cj_ch3.sweep_along_path(lead_b_sub_cj_ch3_path)
  trace_stub_f_ch3_path = polyline((3.55e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  trace_stub_f_ch3 = polyline((3.55e-05, -0.00161, 0) (3.55e-05, -0.00162, 0))
  trace_stub_f_ch3.sweep_along_path(trace_stub_f_ch3_path)
  cut_stub_f_ch3_path = polyline((3.55e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  cut_stub_f_ch3 = polyline((3.55e-05, -0.001604, 0) (3.55e-05, -0.001626, 0))
  cut_stub_f_ch3.sweep_along_path(cut_stub_f_ch3_path)
  trace_stub_r_ch3_path = polyline((0.0001645, -0.001615, 0) (0.0001445, -0.001615, 0))
  trace_stub_r_ch3 = polyline((0.0001645, -0.00162, 0) (0.0001645, -0.00161, 0))
  trace_stub_r_ch3.sweep_along_path(trace_stub_r_ch3_path)
  cut_stub_r_ch3_path = polyline((0.0001645, -0.001615, 0) (0.0001445, -0.001615, 0))
  cut_stub_r_ch3 = polyline((0.0001645, -0.001626, 0) (0.0001645, -0.001604, 0))
  cut_stub_r_ch3.sweep_along_path(cut_stub_r_ch3_path)
  trace_res_a_ch3_path = polyline((0.0002, -0.002915, 0) (0.0002, -0.001765, 0))
  trace_res_a_ch3 = polyline((0.000195, -0.002915, 0) (0.000205, -0.002915, 0))
  trace_res_a_ch3.sweep_along_path(trace_res_a_ch3_path)
  cut_res_a_ch3_path = polyline((0.0002, -0.002915, 0) (0.0002, -0.001765, 0))
  cut_res_a_ch3 = polyline((0.000189, -0.002915, 0) (0.000211, -0.002915, 0))
  cut_res_a_ch3.sweep_along_path(cut_res_a_ch3_path)
  trace_filt_ch3_path = polyline(z=0, xy: (-0.0003, -0.000915) (-0.0003, -0.0022822498) (0, -0.0022822498) (0, -0.001765))
  trace_filt_ch3_path.fillet(Vertices=trace_filt_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  trace_filt_ch3 = polyline((-0.000295, -0.000915, 0) (-0.000305, -0.000915, 0))
  trace_filt_ch3.sweep_along_path(trace_filt_ch3_path)
  cut_filt_ch3_path = polyline(z=0, xy: (-0.0003, -0.000915) (-0.0003, -0.0022822498) (0, -0.0022822498) (0, -0.001765))
  cut_filt_ch3_path.fillet(Vertices=cut_filt_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  cut_filt_ch3 = polyline((-0.000289, -0.000915, 0) (-0.000311, -0.000915, 0))
  cut_filt_ch3.sweep_along_path(cut_filt_ch3_path)
  trace_res_ch3_path = polyline(z=0, xy: (0.00055, -0.00255234) (0.00055, -0.000665) (0.0002, -0.000665) (0.0002, -0.001465))
  trace_res_ch3_path.fillet(Vertices=trace_res_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  trace_res_ch3 = polyline((0.000545, -0.00255234, 0) (0.000555, -0.00255234, 0))
  trace_res_ch3.sweep_along_path(trace_res_ch3_path)
  cut_res_ch3_path = polyline(z=0, xy: (0.00055, -0.00255234) (0.00055, -0.000665) (0.0002, -0.000665) (0.0002, -0.001465))
  cut_res_ch3_path.fillet(Vertices=cut_res_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  cut_res_ch3 = polyline((0.000539, -0.00255234, 0) (0.000561, -0.00255234, 0))
  cut_res_ch3.sweep_along_path(cut_res_ch3_path)
  trace_feed_in_path = polyline((-0.00117, 0, 0) (-0.00015, 0, 0))
  trace_feed_in = polyline((-0.00117, 5e-06, 0) (-0.00117, -5e-06, 0))
  trace_feed_in.sweep_along_path(trace_feed_in_path)
  cut_feed_in_path = polyline((-0.00117, 0, 0) (-0.00015, 0, 0))
  cut_feed_in = polyline((-0.00117, 1.1e-05, 0) (-0.00117, -1.1e-05, 0))
  cut_feed_in.sweep_along_path(cut_feed_in_path)
  trace_feed_out_path = polyline((0.00015, 0, 0) (0.00117, 0, 0))
  trace_feed_out = polyline((0.00015, 5e-06, 0) (0.00015, -5e-06, 0))
  trace_feed_out.sweep_along_path(trace_feed_out_path)
  cut_feed_out_path = polyline((0.00015, 0, 0) (0.00117, 0, 0))
  cut_feed_out = polyline((0.00015, 1.1e-05, 0) (0.00015, -1.1e-05, 0))
  cut_feed_out.sweep_along_path(cut_feed_out_path)
  g_wb [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-5.5e-05 YPadPos=-0.000765 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_1 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-5.5e-05 YPadPos=-0.001115 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_2 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000255 YPadPos=-0.0025316667 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_3 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000255 YPadPos=-0.0021483333 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_4 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0012568124 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_5 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0015986249 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_6 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0019404373 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_7 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=5.5e-05 YPadPos=-0.0020236249 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_8 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.002174872 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_9 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001797404 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_10 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001419936 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_11 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001042468 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_12 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000145 YPadPos=-0.00093166667 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_13 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000145 YPadPos=-0.0011983333 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_14 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00083 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_15 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00049 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_16 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00049 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_17 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00083 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  tap_trace_n0_ch3 = polyline(z=0, xy: (-5e-06, -0.0001) (-5e-06, -5e-06) (-0.00015, -5e-06) (-0.00015, 5e-06) (0.00015, 5e-06) (0.00015, -5e-06) (5e-06, -5e-06) (5e-06, -0.0001) (-5e-06, -0.0001), closed, covered)
  tap_cut_n0_ch3 = polyline(z=0, xy: (-1.1e-05, -0.0001) (-1.1e-05, -1.1e-05) (-0.00015, -1.1e-05) (-0.00015, 1.1e-05) (0.00015, 1.1e-05) (0.00015, -1.1e-05) (1.1e-05, -1.1e-05) (1.1e-05, -0.0001) (-1.1e-05, -0.0001), closed, covered)
  plate_cp_ch3 = polyline(z=0, xy: (8.25e-05, -0.000295) (8.2461478e-05, -0.00029578414) (8.2346282e-05, -0.00029656072) (8.2155523e-05, -0.00029732228) (8.1891036e-05, -0.00029806147) (8.155537e-05, -0.00029877117) (8.1151757e-05, -0.00029944456) (8.0684084e-05, -0.00030007515) (8.0156854e-05, -0.00030065685) (7.9575146e-05, -0.00030118408) (7.8944562e-05, -0.00030165176) (7.8271174e-05, -0.00030205537) (7.7561467e-05, -0.00030239104) (7.6822277e-05, -0.00030265552) (7.6060723e-05, -0.00030284628) (7.5284137e-05, -0.00030296148) (7.45e-05, -0.000303) (-7.45e-05, -0.000303) (-7.5284137e-05, -0.00030296148) (-7.6060723e-05, -0.00030284628) (-7.6822277e-05, -0.00030265552) (-7.7561467e-05, -0.00030239104) (-7.8271174e-05, -0.00030205537) (-7.8944562e-05, -0.00030165176) (-7.9575146e-05, -0.00030118408) (-8.0156854e-05, -0.00030065685) (-8.0684084e-05, -0.00030007515) (-8.1151757e-05, -0.00029944456) (-8.155537e-05, -0.00029877117) (-8.1891036e-05, -0.00029806147) (-8.2155523e-05, -0.00029732228) (-8.2346282e-05, -0.00029656072) (-8.2461478e-05, -0.00029578414) (-8.25e-05, -0.000295) (-8.25e-05, -0.00027) (-8.2461478e-05, -0.00026921586) (-8.2346282e-05, -0.00026843928) (-8.2155523e-05, -0.00026767772) (-8.1891036e-05, -0.00026693853) (-8.155537e-05, -0.00026622883) (-8.1151757e-05, -0.00026555544) (-8.0684084e-05, -0.00026492485) (-8.0156854e-05, -0.00026434315) (-7.9575146e-05, -0.00026381592) (-7.8944562e-05, -0.00026334824) (-7.8271174e-05, -0.00026294463) (-7.7561467e-05, -0.00026260896) (-7.6822277e-05, -0.00026234448) (-7.6060723e-05, -0.00026215372) (-7.5284137e-05, -0.00026203852) (-7.45e-05, -0.000262) (7.45e-05, -0.000262) (7.5284137e-05, -0.00026203852) (7.6060723e-05, -0.00026215372) (7.6822277e-05, -0.00026234448) (7.7561467e-05, -0.00026260896) (7.8271174e-05, -0.00026294463) (7.8944562e-05, -0.00026334824) (7.9575146e-05, -0.00026381592) (8.0156854e-05, -0.00026434315) (8.0684084e-05, -0.00026492485) (8.1151757e-05, -0.00026555544) (8.155537e-05, -0.00026622883) (8.1891036e-05, -0.00026693853) (8.2155523e-05, -0.00026767772) (8.2346282e-05, -0.00026843928) (8.2461478e-05, -0.00026921586) (8.25e-05, -0.00027) (8.25e-05, -0.000295), closed, covered)
  frame_cp_ch3 = polyline(z=0, xy: (8.25e-05, -0.000311) (8.3284137e-05, -0.00031096148) (8.4060723e-05, -0.00031084628) (8.4822277e-05, -0.00031065552) (8.5561467e-05, -0.00031039104) (8.6271174e-05, -0.00031005537) (8.6944562e-05, -0.00030965176) (8.7575146e-05, -0.00030918408) (8.8156854e-05, -0.00030865685) (8.8684084e-05, -0.00030807515) (8.9151757e-05, -0.00030744456) (8.955537e-05, -0.00030677117) (8.9891036e-05, -0.00030606147) (9.0155523e-05, -0.00030532228) (9.0346282e-05, -0.00030456072) (9.0461478e-05, -0.00030378414) (9.05e-05, -0.000303) (9.05e-05, -0.000262) (9.0461478e-05, -0.00026121586) (9.0346282e-05, -0.00026043928) (9.0155523e-05, -0.00025967772) (8.9891036e-05, -0.00025893853) (8.955537e-05, -0.00025822883) (8.9151757e-05, -0.00025755544) (8.8684084e-05, -0.00025692485) (8.8156854e-05, -0.00025634315) (8.7575146e-05, -0.00025581592) (8.6944562e-05, -0.00025534824) (8.6271174e-05, -0.00025494463) (8.5561467e-05, -0.00025460896) (8.4822277e-05, -0.00025434448) (8.4060723e-05, -0.00025415372) (8.3284137e-05, -0.00025403852) (8.25e-05, -0.000254) (1.909818e-05, -0.000254) (1.8901939e-05, -0.00025399518) (1.8412015e-05, -0.00025397111) (1.80216e-05, -0.00025393266) (1.7633541e-05, -0.0002538751) (1.7248774e-05, -0.00025379856) (1.6868226e-05, -0.00025370324) (1.6492814e-05, -0.00025358936) (1.6123441e-05, -0.0002534572) (1.5760999e-05, -0.00025330707) (1.540636e-05, -0.00025313934) (1.5060378e-05, -0.00025295441) (1.4723887e-05, -0.00025275272) (1.4397697e-05, -0.00025253477) (1.4082595e-05, -0.00025230107) (1.3779339e-05, -0.0002520522) (1.348866e-05, -0.00025178874) (1.3211259e-05, -0.00025151134) (1.2947803e-05, -0.00025122066) (1.2698928e-05, -0.0002509174) (1.2465232e-05, -0.0002506023) (1.2247279e-05, -0.00025027611) (1.2045594e-05, -0.00024993962) (1.1860663e-05, -0.00024959364) (1.1692931e-05, -0.000249239) (1.1542802e-05, -0.00024887656) (1.1410639e-05, -0.00024850719) (1.1296759e-05, -0.00024813177) (1.1201436e-05, -0.00024775123) (1.1124902e-05, -0.00024736646) (1.1067338e-05, -0.0002469784) (1.1028886e-05, -0.00024658799) (1.1004817e-05, -0.00024609806) (1.1e-05, -0.00024590182) (1.1e-05, -0.00019809818) (1.1004817e-05, -0.00019790194) (1.1028886e-05, -0.00019741201) (1.1067338e-05, -0.0001970216) (1.1124902e-05, -0.00019663354) (1.1201436e-05, -0.00019624877) (1.1296759e-05, -0.00019586823) (1.1410639e-05, -0.00019549281) (1.1542802e-05, -0.00019512344) (1.1692931e-05, -0.000194761) (1.1860663e-05, -0.00019440636) (1.2045594e-05, -0.00019406038) (1.2247279e-05, -0.00019372389) (1.2465232e-05, -0.0001933977) (1.2698928e-05, -0.00019308259) (1.2947803e-05, -0.00019277934) (1.3211259e-05, -0.00019248866) (1.348866e-05, -0.00019221126) (1.3779339e-05, -0.0001919478) (1.4082595e-05, -0.00019169893) (1.4397697e-05, -0.00019146523) (1.4723887e-05, -0.00019124728) (1.5060378e-05, -0.00019104559) (1.540636e-05, -0.00019086066) (1.5760999e-05, -0.00019069293) (1.6123441e-05, -0.0001905428) (1.6492814e-05, -0.00019041064) (1.6868226e-05, -0.00019029676) (1.7248774e-05, -0.00019020144) (1.7633541e-05, -0.0001901249) (1.80216e-05, -0.00019006734) (1.8412015e-05, -0.00019002889) (1.8901939e-05, -0.00019000482) (1.909818e-05, -0.00019) (0.00013940182, -0.00019) (0.00013959806, -0.00019000482) (0.00014008798, -0.00019002889) (0.0001404784, -0.00019006734) (0.00014086646, -0.0001901249) (0.00014125123, -0.00019020144) (0.00014163177, -0.00019029676) (0.00014200719, -0.00019041064) (0.00014237656, -0.0001905428) (0.000142739, -0.00019069293) (0.00014309364, -0.00019086066) (0.00014343962, -0.00019104559) (0.00014377611, -0.00019124728) (0.0001441023, -0.00019146523) (0.0001444174, -0.00019169893) (0.00014472066, -0.0001919478) (0.00014501134, -0.00019221126) (0.00014528874, -0.00019248866) (0.0001455522, -0.00019277934) (0.00014580107, -0.00019308259) (0.00014603477, -0.0001933977) (0.00014625272, -0.00019372389) (0.00014645441, -0.00019406038) (0.00014663934, -0.00019440636) (0.00014680707, -0.000194761) (0.0001469572, -0.00019512344) (0.00014708936, -0.00019549281) (0.00014720324, -0.00019586823) (0.00014729856, -0.00019624877) (0.0001473751, -0.00019663354) (0.00014743266, -0.0001970216) (0.00014747111, -0.00019741201) (0.00014749518, -0.00019790194) (0.0001475, -0.00019809818) (0.0001475, -0.00035490182) (0.00014749518, -0.00035509806) (0.00014747111, -0.00035558799) (0.00014743266, -0.0003559784) (0.0001473751, -0.00035636646) (0.00014729856, -0.00035675123) (0.00014720324, -0.00035713177) (0.00014708936, -0.00035750719) (0.0001469572, -0.00035787656) (0.00014680707, -0.000358239) (0.00014663934, -0.00035859364) (0.00014645441, -0.00035893962) (0.00014625272, -0.00035927611) (0.00014603477, -0.0003596023) (0.00014580107, -0.00035991741) (0.0001455522, -0.00036022066) (0.00014528874, -0.00036051134) (0.00014501134, -0.00036078874) (0.00014472066, -0.0003610522) (0.0001444174, -0.00036130107) (0.0001441023, -0.00036153477) (0.00014377611, -0.00036175272) (0.00014343962, -0.00036195441) (0.00014309364, -0.00036213934) (0.000142739, -0.00036230707) (0.00014237656, -0.0003624572) (0.00014200719, -0.00036258936) (0.00014163177, -0.00036270324) (0.00014125123, -0.00036279856) (0.00014086646, -0.0003628751) (0.0001404784, -0.00036293266) (0.00014008798, -0.00036297111) (0.00013959806, -0.00036299518) (0.00013940182, -0.000363) (-0.00013940182, -0.000363) (-0.00013959806, -0.00036299518) (-0.00014008798, -0.00036297111) (-0.0001404784, -0.00036293266) (-0.00014086646, -0.0003628751) (-0.00014125123, -0.00036279856) (-0.00014163177, -0.00036270324) (-0.00014200719, -0.00036258936) (-0.00014237656, -0.0003624572) (-0.000142739, -0.00036230707) (-0.00014309364, -0.00036213934) (-0.00014343962, -0.00036195441) (-0.00014377611, -0.00036175272) (-0.0001441023, -0.00036153477) (-0.0001444174, -0.00036130107) (-0.00014472066, -0.0003610522) (-0.00014501134, -0.00036078874) (-0.00014528874, -0.00036051134) (-0.0001455522, -0.00036022066) (-0.00014580107, -0.00035991741) (-0.00014603477, -0.0003596023) (-0.00014625272, -0.00035927611) (-0.00014645441, -0.00035893962) (-0.00014663934, -0.00035859364) (-0.00014680707, -0.000358239) (-0.0001469572, -0.00035787656) (-0.00014708936, -0.00035750719) (-0.00014720324, -0.00035713177) (-0.00014729856, -0.00035675123) (-0.0001473751, -0.00035636646) (-0.00014743266, -0.0003559784) (-0.00014747111, -0.00035558799) (-0.00014749518, -0.00035509806) (-0.0001475, -0.00035490182) (-0.0001475, -0.00019809818) (-0.00014749518, -0.00019790194) (-0.00014747111, -0.00019741201) (-0.00014743266, -0.0001970216) (-0.0001473751, -0.00019663354) (-0.00014729856, -0.00019624877) (-0.00014720324, -0.00019586823) (-0.00014708936, -0.00019549281) (-0.0001469572, -0.00019512344) (-0.00014680707, -0.000194761) (-0.00014663934, -0.00019440636) (-0.00014645441, -0.00019406038) (-0.00014625272, -0.00019372389) (-0.00014603477, -0.0001933977) (-0.00014580107, -0.00019308259) (-0.0001455522, -0.00019277934) (-0.00014528874, -0.00019248866) (-0.00014501134, -0.00019221126) (-0.00014472066, -0.0001919478) (-0.0001444174, -0.00019169893) (-0.0001441023, -0.00019146523) (-0.00014377611, -0.00019124728) (-0.00014343962, -0.00019104559) (-0.00014309364, -0.00019086066) (-0.000142739, -0.00019069293) (-0.00014237656, -0.0001905428) (-0.00014200719, -0.00019041064) (-0.00014163177, -0.00019029676) (-0.00014125123, -0.00019020144) (-0.00014086646, -0.0001901249) (-0.0001404784, -0.00019006734) (-0.00014008798, -0.00019002889) (-0.00013959806, -0.00019000482) (-0.00013940182, -0.00019) (-1.909818e-05, -0.00019) (-1.8901939e-05, -0.00019000482) (-1.8412015e-05, -0.00019002889) (-1.80216e-05, -0.00019006734) (-1.7633541e-05, -0.0001901249) (-1.7248774e-05, -0.00019020144) (-1.6868226e-05, -0.00019029676) (-1.6492814e-05, -0.00019041064) (-1.6123441e-05, -0.0001905428) (-1.5760999e-05, -0.00019069293) (-1.540636e-05, -0.00019086066) (-1.5060378e-05, -0.00019104559) (-1.4723887e-05, -0.00019124728) (-1.4397697e-05, -0.00019146523) (-1.4082595e-05, -0.00019169893) (-1.3779339e-05, -0.0001919478) (-1.348866e-05, -0.00019221126) (-1.3211259e-05, -0.00019248866) (-1.2947803e-05, -0.00019277934) (-1.2698928e-05, -0.00019308259) (-1.2465232e-05, -0.0001933977) (-1.2247279e-05, -0.00019372389) (-1.2045594e-05, -0.00019406038) (-1.1860663e-05, -0.00019440636) (-1.1692931e-05, -0.000194761) (-1.1542802e-05, -0.00019512344) (-1.1410639e-05, -0.00019549281) (-1.1296759e-05, -0.00019586823) (-1.1201436e-05, -0.00019624877) (-1.1124902e-05, -0.00019663354) (-1.1067338e-05, -0.0001970216) (-1.1028886e-05, -0.00019741201) (-1.1004817e-05, -0.00019790194) (-1.1e-05, -0.00019809818) (-1.1e-05, -0.00024590182) (-1.1004817e-05, -0.00024609806) (-1.1028886e-05, -0.00024658799) (-1.1067338e-05, -0.0002469784) (-1.1124902e-05, -0.00024736646) (-1.1201436e-05, -0.00024775123) (-1.1296759e-05, -0.00024813177) (-1.1410639e-05, -0.00024850719) (-1.1542802e-05, -0.00024887656) (-1.1692931e-05, -0.000249239) (-1.1860663e-05, -0.00024959364) (-1.2045594e-05, -0.00024993962) (-1.2247279e-05, -0.00025027611) (-1.2465232e-05, -0.0002506023) (-1.2698928e-05, -0.0002509174) (-1.2947803e-05, -0.00025122066) (-1.3211259e-05, -0.00025151134) (-1.348866e-05, -0.00025178874) (-1.3779339e-05, -0.0002520522) (-1.4082595e-05, -0.00025230107) (-1.4397697e-05, -0.00025253477) (-1.4723887e-05, -0.00025275272) (-1.5060378e-05, -0.00025295441) (-1.540636e-05, -0.00025313934) (-1.5760999e-05, -0.00025330707) (-1.6123441e-05, -0.0002534572) (-1.6492814e-05, -0.00025358936) (-1.6868226e-05, -0.00025370324)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, closed, covered)
  pocket_cp_ch3 = polyline(z=0, xy: (0.0001475, -0.000375) (-0.0001475, -0.000375) (-0.00014867621, -0.00037494222) (-0.00014984108, -0.00037476942) (-0.00015098342, -0.00037448328) (-0.0001520922, -0.00037408655) (-0.00015315676, -0.00037358305) (-0.00015416684, -0.00037297763) (-0.00015511272, -0.00037227612) (-0.00015598528, -0.00037148528) (-0.00015677613, -0.00037061272) (-0.00015747764, -0.00036966684) (-0.00015808305, -0.00036865676) (-0.00015858655, -0.0003675922) (-0.00015898328, -0.00036648342) (-0.00015926942, -0.00036534108) (-0.00015944222, -0.00036417621) (-0.0001595, -0.000363) (-0.0001595, -0.00019) (-0.00015944222, -0.00018882379) (-0.00015926942, -0.00018765892) (-0.00015898328, -0.00018651658) (-0.00015858655, -0.0001854078) (-0.00015808305, -0.00018434324) (-0.00015747764, -0.00018333316) (-0.00015677613, -0.00018238728) (-0.00015598528, -0.00018151472) (-0.00015511272, -0.00018072388) (-0.00015416684, -0.00018002237) (-0.00015315676, -0.00017941694) (-0.0001520922, -0.00017891345) (-0.00015098342, -0.00017851672) (-0.00014984108, -0.00017823058) (-0.00014867621, -0.00017805778) (-0.0001475, -0.000178) (0.0001475, -0.000178) (0.00014867621, -0.00017805778) (0.00014984108, -0.00017823058) (0.00015098342, -0.00017851672) (0.0001520922, -0.00017891345) (0.00015315676, -0.00017941694) (0.00015416684, -0.00018002237) (0.00015511272, -0.00018072388) (0.00015598528, -0.00018151472) (0.00015677613, -0.00018238728) (0.00015747764, -0.00018333316) (0.00015808305, -0.00018434324) (0.00015858655, -0.0001854078) (0.00015898328, -0.00018651658) (0.00015926942, -0.00018765892) (0.00015944222, -0.00018882379) (0.0001595, -0.00019) (0.0001595, -0.000363) (0.00015944222, -0.00036417621) (0.00015926942, -0.00036534108) (0.00015898328, -0.00036648342) (0.00015858655, -0.0003675922) (0.00015808305, -0.00036865676) (0.00015747764, -0.00036966684) (0.00015677613, -0.00037061272) (0.00015598528, -0.00037148528) (0.00015511272, -0.00037227612) (0.00015416684, -0.00037297763) (0.00015315676, -0.00037358305) (0.0001520922, -0.00037408655) (0.00015098342, -0.00037448328) (0.00014984108, -0.00037476942) (0.00014867621, -0.00037494222) (0.0001475, -0.000375), closed, covered)
  tap_trace_jf_ch3 = polyline(z=0, xy: (5e-06, -0.001465) (5e-06, -0.00161) (3.55e-05, -0.00161) (3.55e-05, -0.00162) (5e-06, -0.00162) (5e-06, -0.001765) (-5e-06, -0.001765) (-5e-06, -0.001465) (5e-06, -0.001465), closed, covered)
  tap_cut_jf_ch3 = polyline(z=0, xy: (1.1e-05, -0.001465) (1.1e-05, -0.001604) (3.55e-05, -0.001604) (3.55e-05, -0.001626) (1.1e-05, -0.001626) (1.1e-05, -0.001765) (-1.1e-05, -0.001765) (-1.1e-05, -0.001465) (1.1e-05, -0.001465), closed, covered)
  tap_trace_jr_ch3 = polyline(z=0, xy: (0.0001645, -0.00161) (0.000195, -0.00161) (0.000195, -0.001465) (0.000205, -0.001465) (0.000205, -0.001765) (0.000195, -0.001765) (0.000195, -0.00162) (0.0001645, -0.00162) (0.0001645, -0.00161), closed, covered)
  tap_cut_jr_ch3 = polyline(z=0, xy: (0.0001645, -0.001604) (0.000189, -0.001604) (0.000189, -0.001465) (0.000211, -0.001465) (0.000211, -0.001765) (0.000189, -0.001765) (0.000189, -0.001626) (0.0001645, -0.001626) (0.0001645, -0.001604), closed, covered)
  head_a_cj_ch3 = polyline(z=0, xy: (6.75e-05, -0.0016475) (6.7303966e-05, -0.0016474904) (6.7109819e-05, -0.0016474616) (6.6919431e-05, -0.0016474139) (6.6734633e-05, -0.0016473478) (6.6557207e-05, -0.0016472638) (6.638886e-05, -0.0016471629) (6.6231213e-05, -0.001647046) (6.6085786e-05, -0.0016469142) (6.5953979e-05, -0.0016467688) (6.5837061e-05, -0.0016466111) (6.5736157e-05, -0.0016464428) (6.5652241e-05, -0.0016462654) (6.5586119e-05, -0.0016460806) (6.5538429e-05, -0.0016458902) (6.5509631e-05, -0.001645696) (6.55e-05, -0.0016455) (6.55e-05, -0.0015845) (6.5509631e-05, -0.001584304) (6.5538429e-05, -0.0015841098) (6.5586119e-05, -0.0015839194) (6.5652241e-05, -0.0015837346) (6.5736157e-05, -0.0015835572) (6.5837061e-05, -0.0015833889) (6.5953979e-05, -0.0015832312) (6.6085786e-05, -0.0015830858) (6.6231213e-05, -0.001582954) (6.638886e-05, -0.0015828371) (6.6557207e-05, -0.0015827362) (6.6734633e-05, -0.0015826522) (6.6919431e-05, -0.0015825861) (6.7109819e-05, -0.0015825384) (6.7303966e-05, -0.0015825096) (6.75e-05, -0.0015825) (8.85e-05, -0.0015825) (8.8696034e-05, -0.0015825096) (8.8890181e-05, -0.0015825384) (8.9080569e-05, -0.0015825861) (8.9265367e-05, -0.0015826522) (8.9442793e-05, -0.0015827362) (8.961114e-05, -0.0015828371) (8.9768787e-05, -0.001582954) (8.9914214e-05, -0.0015830858) (9.0046021e-05, -0.0015832312) (9.0162939e-05, -0.0015833889) (9.0263843e-05, -0.0015835572) (9.0347759e-05, -0.0015837346) (9.0413881e-05, -0.0015839194) (9.0461571e-05, -0.0015841098) (9.0490369e-05, -0.001584304) (9.05e-05, -0.0015845) (9.05e-05, -0.0016455) (9.0490369e-05, -0.001645696) (9.0461571e-05, -0.0016458902) (9.0413881e-05, -0.0016460806) (9.0347759e-05, -0.0016462654) (9.0263843e-05, -0.0016464428) (9.0162939e-05, -0.0016466111) (9.0046021e-05, -0.0016467688) (8.9914214e-05, -0.0016469142) (8.9768787e-05, -0.001647046) (8.961114e-05, -0.0016471629) (8.9442793e-05, -0.0016472638) (8.9265367e-05, -0.0016473478) (8.9080569e-05, -0.0016474139) (8.8890181e-05, -0.0016474616) (8.8696034e-05, -0.0016474904) (8.85e-05, -0.0016475) (6.75e-05, -0.0016475), closed, covered)
  head_b_cj_ch3 = polyline(z=0, xy: (0.0001115, -0.0016475) (0.00011130397, -0.0016474904) (0.00011110982, -0.0016474616) (0.00011091943, -0.0016474139) (0.00011073463, -0.0016473478) (0.00011055721, -0.0016472638) (0.00011038886, -0.0016471629) (0.00011023121, -0.001647046) (0.00011008579, -0.0016469142) (0.00010995398, -0.0016467688) (0.00010983706, -0.0016466111) (0.00010973616, -0.0016464428) (0.00010965224, -0.0016462654) (0.00010958612, -0.0016460806) (0.00010953843, -0.0016458902) (0.00010950963, -0.001645696) (0.0001095, -0.0016455) (0.0001095, -0.0015845) (0.00010950963, -0.001584304) (0.00010953843, -0.0015841098) (0.00010958612, -0.0015839194) (0.00010965224, -0.0015837346) (0.00010973616, -0.0015835572) (0.00010983706, -0.0015833889) (0.00010995398, -0.0015832312) (0.00011008579, -0.0015830858) (0.00011023121, -0.001582954) (0.00011038886, -0.0015828371) (0.00011055721, -0.0015827362) (0.00011073463, -0.0015826522) (0.00011091943, -0.0015825861) (0.00011110982, -0.0015825384) (0.00011130397, -0.0015825096) (0.0001115, -0.0015825) (0.0001325, -0.0015825) (0.00013269603, -0.0015825096) (0.00013289018, -0.0015825384) (0.00013308057, -0.0015825861) (0.00013326537, -0.0015826522) (0.00013344279, -0.0015827362) (0.00013361114, -0.0015828371) (0.00013376879, -0.001582954) (0.00013391421, -0.0015830858) (0.00013404602, -0.0015832312) (0.00013416294, -0.0015833889) (0.00013426384, -0.0015835572) (0.00013434776, -0.0015837346) (0.00013441388, -0.0015839194) (0.00013446157, -0.0015841098) (0.00013449037, -0.001584304) (0.0001345, -0.0015845) (0.0001345, -0.0016455) (0.00013449037, -0.001645696) (0.00013446157, -0.0016458902) (0.00013441388, -0.0016460806) (0.00013434776, -0.0016462654) (0.00013426384, -0.0016464428) (0.00013416294, -0.0016466111) (0.00013404602, -0.0016467688) (0.00013391421, -0.0016469142) (0.00013376879, -0.001647046) (0.00013361114, -0.0016471629) (0.00013344279, -0.0016472638) (0.00013326537, -0.0016473478) (0.00013308057, -0.0016474139) (0.00013289018, -0.0016474616) (0.00013269603, -0.0016474904) (0.0001325, -0.0016475) (0.0001115, -0.0016475), closed, covered)
  pocket_cj_ch3 = polyline(z=0, xy: (5.15e-05, -0.0016635) (5.1303966e-05, -0.0016634904) (5.1109819e-05, -0.0016634616) (5.0919431e-05, -0.0016634139) (5.0734633e-05, -0.0016633478) (5.0557207e-05, -0.0016632638) (5.038886e-05, -0.0016631629) (5.0231213e-05, -0.001663046) (5.0085786e-05, -0.0016629142) (4.9953979e-05, -0.0016627688) (4.9837061e-05, -0.0016626111) (4.9736157e-05, -0.0016624428) (4.9652241e-05, -0.0016622654) (4.9586119e-05, -0.0016620806) (4.9538429e-05, -0.0016618902) (4.9509631e-05, -0.001661696) (4.95e-05, -0.0016615) (4.95e-05, -0.0015685) (4.9509631e-05, -0.001568304) (4.9538429e-05, -0.0015681098) (4.9586119e-05, -0.0015679194) (4.9652241e-05, -0.0015677346) (4.9736157e-05, -0.0015675572) (4.9837061e-05, -0.0015673889) (4.9953979e-05, -0.0015672312) (5.0085786e-05, -0.0015670858) (5.0231213e-05, -0.001566954) (5.038886e-05, -0.0015668371) (5.0557207e-05, -0.0015667362) (5.0734633e-05, -0.0015666522) (5.0919431e-05, -0.0015665861) (5.1109819e-05, -0.0015665384) (5.1303966e-05, -0.0015665096) (5.15e-05, -0.0015665) (0.0001485, -0.0015665) (0.00014869603, -0.0015665096) (0.00014889018, -0.0015665384) (0.00014908057, -0.0015665861) (0.00014926537, -0.0015666522) (0.00014944279, -0.0015667362) (0.00014961114, -0.0015668371) (0.00014976879, -0.001566954) (0.00014991421, -0.0015670858) (0.00015004602, -0.0015672312) (0.00015016294, -0.0015673889) (0.00015026384, -0.0015675572) (0.00015034776, -0.0015677346) (0.00015041388, -0.0015679194) (0.00015046157, -0.0015681098) (0.00015049037, -0.001568304) (0.0001505, -0.0015685) (0.0001505, -0.0016615) (0.00015049037, -0.001661696) (0.00015046157, -0.0016618902) (0.00015041388, -0.0016620806) (0.00015034776, -0.0016622654) (0.00015026384, -0.0016624428) (0.00015016294, -0.0016626111) (0.00015004602, -0.0016627688) (0.00014991421, -0.0016629142) (0.00014976879, -0.001663046) (0.00014961114, -0.0016631629) (0.00014944279, -0.0016632638) (0.00014926537, -0.0016633478) (0.00014908057, -0.0016634139) (0.00014889018, -0.0016634616) (0.00014869603, -0.0016634904) (0.0001485, -0.0016635) (5.15e-05, -0.0016635), closed, covered)
  endcap_res_a_ch3_start = rectangle(corner=(0.000189, -0.002921, 0), x_size=2.2e-05, y_size=6e-06)
  endcap_feed_in_start = rectangle(corner=(-0.001176, -1.1e-05, 0), x_size=6e-06, y_size=2.2e-05)
  endcap_feed_out_end = rectangle(corner=(0.00117, -1.1e-05, 0), x_size=6e-06, y_size=2.2e-05)
  ground_main_plane = rectangle(corner=(-0.00137, -0.003115, 0), x_size=0.00274, y_size=0.003326)
  main [silicon] = box(corner=(-0.00137, -0.003115, -0.000525), size=(0.00274, 0.003326, 0.000525))
  sample_holder [vacuum] = box(corner=(-0.00137, -0.003115, -0.00165), size=(0.00274, 0.003326, 0.00254))
  ground_main_plane.subtract(endcap_res_a_ch3_start, lead_a_sub_cp_ch3, cut_res_a_ch3, cut_feed_jf_ch3, cut_filt_ch3, cut_feed_in, pocket_cp_ch3, tap_cut_jf_ch3, lead_b_sub_cp_ch3, endcap_feed_out_end, lead_b_sub_cj_ch3, tap_cut_jr_ch3, tap_cut_n0_ch3, lead_a_sub_cj_ch3, pocket_cj_ch3, endcap_feed_in_start, cut_stub_p_ch3, cut_feed_out, cut_stub_r_ch3, cut_res_ch3, cut_stub_f_ch3)
  Port_feed_in_start = rectangle(corner=(-0.001176, -5e-06, 0), x_size=6e-06, y_size=1e-05)
  voltage_line_Port_feed_in_start = polyline((-0.00117, 0, 0) (-0.001176, 0, 0))
  Port_feed_out_end = rectangle(corner=(0.00117, -5e-06, 0), x_size=6e-06, y_size=1e-05)
  voltage_line_Port_feed_out_end = polyline((0.00117, 0, 0) (0.001176, 0, 0))
boundaries and excitations:
  RLCBoundary_feed_in_start: Lumped RLC Objects=Port_feed_in_start CurrentLine{middle of Port_feed_in_start.edge(x at corner) -> middle of Port_feed_in_start.edge(x opposite corner)} RLC_Type=Parallel Resistance=50ohm
  RLCBoundary_feed_out_end: Lumped RLC Objects=Port_feed_out_end CurrentLine{middle of Port_feed_out_end.edge(x at corner) -> middle of Port_feed_out_end.edge(x opposite corner)} RLC_Type=Parallel Resistance=50ohm
  PerfE: Perfect E Objects=[lead_a_cp_ch3, lead_b_cp_ch3, trace_stub_p_ch3, trace_feed_jf_ch3, lead_a_cj_ch3, lead_b_cj_ch3, trace_stub_f_ch3, trace_stub_r_ch3, trace_res_a_ch3, trace_filt_ch3, trace_res_ch3, trace_feed_in, trace_feed_out, tap_trace_n0_ch3, plate_cp_ch3, frame_cp_ch3, tap_trace_jf_ch3, tap_trace_jr_ch3, head_a_cj_ch3, head_b_cj_ch3, ground_main_plane]
mesh:
  port_mesh: LengthBased Objects=[Port_feed_in_start, Port_feed_out_end] MaxLength=7um
  cpw_line_mesh: LengthBased Objects=[trace_stub_p_ch3, trace_feed_jf_ch3, trace_stub_f_ch3, trace_stub_r_ch3, trace_res_a_ch3, trace_filt_ch3, trace_res_ch3, trace_feed_in, trace_feed_out, tap_trace_n0_ch3, tap_trace_jf_ch3, tap_trace_jr_ch3] MaxLength=10um
  cap_mesh: LengthBased Objects=[lead_a_cp_ch3, lead_b_cp_ch3, lead_a_cj_ch3, lead_b_cj_ch3, plate_cp_ch3, frame_cp_ch3, head_a_cj_ch3, head_b_cj_ch3] MaxLength=5um
setups:
  Setup: HfssEigen MinimumFrequency=6.5GHz NumModes=2 MaxDeltaFreq=0.1 ConvergeOnRealFreq=true MaximumPasses=15 MinimumPasses=3 MinimumConvergedPasses=2 PercentRefinement=20 BasisOrder=1
source amplitudes:
  #-10:1: 1 0deg
  #-10:2: 0 0deg
field plots:
  Mesh1: MeshPlots on Setup : LastAdaptive at Phase=0deg

design v6_full_1600_hfss (HFSS, DrivenModal, model units mm)
geometry:
  lead_a_cp_ch3_path = polyline((0, -0.000362999, 0) (0, -0.000415, 0))
  lead_a_cp_ch3 = polyline((5e-06, -0.000362999, 0) (-5e-06, -0.000362999, 0))
  lead_a_cp_ch3.sweep_along_path(lead_a_cp_ch3_path)
  lead_a_sub_cp_ch3_path = polyline((0, -0.000362999, 0) (0, -0.000415, 0))
  lead_a_sub_cp_ch3 = polyline((1.1e-05, -0.000362999, 0) (-1.1e-05, -0.000362999, 0))
  lead_a_sub_cp_ch3.sweep_along_path(lead_a_sub_cp_ch3_path)
  lead_b_cp_ch3_path = polyline((0, -0.000262001, 0) (0, -0.00015, 0))
  lead_b_cp_ch3 = polyline((-5e-06, -0.000262001, 0) (5e-06, -0.000262001, 0))
  lead_b_cp_ch3.sweep_along_path(lead_b_cp_ch3_path)
  lead_b_sub_cp_ch3_path = polyline((0, -0.000262001, 0) (0, -0.00015, 0))
  lead_b_sub_cp_ch3 = polyline((-1.1e-05, -0.000262001, 0) (1.1e-05, -0.000262001, 0))
  lead_b_sub_cp_ch3.sweep_along_path(lead_b_sub_cp_ch3_path)
  trace_stub_p_ch3_path = polyline((0, -0.0001, 0) (0, -0.00015, 0))
  trace_stub_p_ch3 = polyline((5e-06, -0.0001, 0) (-5e-06, -0.0001, 0))
  trace_stub_p_ch3.sweep_along_path(trace_stub_p_ch3_path)
  cut_stub_p_ch3_path = polyline((0, -0.0001, 0) (0, -0.00015, 0))
  cut_stub_p_ch3 = polyline((1.1e-05, -0.0001, 0) (-1.1e-05, -0.0001, 0))
  cut_stub_p_ch3.sweep_along_path(cut_stub_p_ch3_path)
  trace_feed_jf_ch3_path = polyline((0, -0.000415, 0) (0, -0.001465, 0))
  trace_feed_jf_ch3 = polyline((5e-06, -0.000415, 0) (-5e-06, -0.000415, 0))
  trace_feed_jf_ch3.sweep_along_path(trace_feed_jf_ch3_path)
  cut_feed_jf_ch3_path = polyline((0, -0.000415, 0) (0, -0.001465, 0))
  cut_feed_jf_ch3 = polyline((1.1e-05, -0.000415, 0) (-1.1e-05, -0.000415, 0))
  cut_feed_jf_ch3.sweep_along_path(cut_feed_jf_ch3_path)
  lead_a_cj_ch3_path = polyline((6.5501e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  lead_a_cj_ch3 = polyline((6.5501e-05, -0.00162, 0) (6.5501e-05, -0.00161, 0))
  lead_a_cj_ch3.sweep_along_path(lead_a_cj_ch3_path)
  lead_a_sub_cj_ch3_path = polyline((6.5501e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  lead_a_sub_cj_ch3 = polyline((6.5501e-05, -0.001626, 0) (6.5501e-05, -0.001604, 0))
  lead_a_sub_cj_ch3.sweep_along_path(lead_a_sub_cj_ch3_path)
  lead_b_cj_ch3_path = polyline((0.000134499, -0.001615, 0) (0.0001445, -0.001615, 0))
  lead_b_cj_ch3 = polyline((0.000134499, -0.00161, 0) (0.000134499, -0.00162, 0))
  lead_b_cj_ch3.sweep_along_path(lead_b_cj_ch3_path)
  lead_b_sub_cj_ch3_path = polyline((0.000134499, -0.001615, 0) (0.0001445, -0.001615, 0))
  lead_b_sub_cj_ch3 = polyline((0.000134499, -0.001604, 0) (0.000134499, -0.001626, 0))
  lead_b_sub_cj_ch3.sweep_along_path(lead_b_sub_cj_ch3_path)
  trace_stub_f_ch3_path = polyline((3.55e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  trace_stub_f_ch3 = polyline((3.55e-05, -0.00161, 0) (3.55e-05, -0.00162, 0))
  trace_stub_f_ch3.sweep_along_path(trace_stub_f_ch3_path)
  cut_stub_f_ch3_path = polyline((3.55e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  cut_stub_f_ch3 = polyline((3.55e-05, -0.001604, 0) (3.55e-05, -0.001626, 0))
  cut_stub_f_ch3.sweep_along_path(cut_stub_f_ch3_path)
  trace_stub_r_ch3_path = polyline((0.0001645, -0.001615, 0) (0.0001445, -0.001615, 0))
  trace_stub_r_ch3 = polyline((0.0001645, -0.00162, 0) (0.0001645, -0.00161, 0))
  trace_stub_r_ch3.sweep_along_path(trace_stub_r_ch3_path)
  cut_stub_r_ch3_path = polyline((0.0001645, -0.001615, 0) (0.0001445, -0.001615, 0))
  cut_stub_r_ch3 = polyline((0.0001645, -0.001626, 0) (0.0001645, -0.001604, 0))
  cut_stub_r_ch3.sweep_along_path(cut_stub_r_ch3_path)
  trace_res_a_ch3_path = polyline((0.0002, -0.002915, 0) (0.0002, -0.001765, 0))
  trace_res_a_ch3 = polyline((0.000195, -0.002915, 0) (0.000205, -0.002915, 0))
  trace_res_a_ch3.sweep_along_path(trace_res_a_ch3_path)
  cut_res_a_ch3_path = polyline((0.0002, -0.002915, 0) (0.0002, -0.001765, 0))
  cut_res_a_ch3 = polyline((0.000189, -0.002915, 0) (0.000211, -0.002915, 0))
  cut_res_a_ch3.sweep_along_path(cut_res_a_ch3_path)
  trace_filt_ch3_path = polyline(z=0, xy: (-0.0003, -0.000915) (-0.0003, -0.0022822498) (0, -0.0022822498) (0, -0.001765))
  trace_filt_ch3_path.fillet(Vertices=trace_filt_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  trace_filt_ch3 = polyline((-0.000295, -0.000915, 0) (-0.000305, -0.000915, 0))
  trace_filt_ch3.sweep_along_path(trace_filt_ch3_path)
  cut_filt_ch3_path = polyline(z=0, xy: (-0.0003, -0.000915) (-0.0003, -0.0022822498) (0, -0.0022822498) (0, -0.001765))
  cut_filt_ch3_path.fillet(Vertices=cut_filt_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  cut_filt_ch3 = polyline((-0.000289, -0.000915, 0) (-0.000311, -0.000915, 0))
  cut_filt_ch3.sweep_along_path(cut_filt_ch3_path)
  trace_res_ch3_path = polyline(z=0, xy: (0.00055, -0.00255234) (0.00055, -0.000665) (0.0002, -0.000665) (0.0002, -0.001465))
  trace_res_ch3_path.fillet(Vertices=trace_res_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  trace_res_ch3 = polyline((0.000545, -0.00255234, 0) (0.000555, -0.00255234, 0))
  trace_res_ch3.sweep_along_path(trace_res_ch3_path)
  cut_res_ch3_path = polyline(z=0, xy: (0.00055, -0.00255234) (0.00055, -0.000665) (0.0002, -0.000665) (0.0002, -0.001465))
  cut_res_ch3_path.fillet(Vertices=cut_res_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  cut_res_ch3 = polyline((0.000539, -0.00255234, 0) (0.000561, -0.00255234, 0))
  cut_res_ch3.sweep_along_path(cut_res_ch3_path)
  trace_feed_in_path = polyline((-0.00117, 0, 0) (-0.00015, 0, 0))
  trace_feed_in = polyline((-0.00117, 5e-06, 0) (-0.00117, -5e-06, 0))
  trace_feed_in.sweep_along_path(trace_feed_in_path)
  cut_feed_in_path = polyline((-0.00117, 0, 0) (-0.00015, 0, 0))
  cut_feed_in = polyline((-0.00117, 1.1e-05, 0) (-0.00117, -1.1e-05, 0))
  cut_feed_in.sweep_along_path(cut_feed_in_path)
  trace_feed_out_path = polyline((0.00015, 0, 0) (0.00117, 0, 0))
  trace_feed_out = polyline((0.00015, 5e-06, 0) (0.00015, -5e-06, 0))
  trace_feed_out.sweep_along_path(trace_feed_out_path)
  cut_feed_out_path = polyline((0.00015, 0, 0) (0.00117, 0, 0))
  cut_feed_out = polyline((0.00015, 1.1e-05, 0) (0.00015, -1.1e-05, 0))
  cut_feed_out.sweep_along_path(cut_feed_out_path)
  g_wb [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-5.5e-05 YPadPos=-0.000765 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_1 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-5.5e-05 YPadPos=-0.001115 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_2 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000255 YPadPos=-0.0025316667 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_3 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000255 YPadPos=-0.0021483333 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_4 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0012568124 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_5 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0015986249 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_6 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0019404373 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_7 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=5.5e-05 YPadPos=-0.0020236249 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_8 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.002174872 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_9 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001797404 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_10 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001419936 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_11 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001042468 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_12 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000145 YPadPos=-0.00093166667 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_13 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000145 YPadPos=-0.0011983333 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_14 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00083 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_15 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00049 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_16 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00049 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_17 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00083 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  tap_trace_n0_ch3 = polyline(z=0, xy: (-5e-06, -0.0001) (-5e-06, -5e-06) (-0.00015, -5e-06) (-0.00015, 5e-06) (0.00015, 5e-06) (0.00015, -5e-06) (5e-06, -5e-06) (5e-06, -0.0001) (-5e-06, -0.0001), closed, covered)
  tap_cut_n0_ch3 = polyline(z=0, xy: (-1.1e-05, -0.0001) (-1.1e-05, -1.1e-05) (-0.00015, -1.1e-05) (-0.00015, 1.1e-05) (0.00015, 1.1e-05) (0.00015, -1.1e-05) (1.1e-05, -1.1e-05) (1.1e-05, -0.0001) (-1.1e-05, -0.0001), closed, covered)
  plate_cp_ch3 = polyline(z=0, xy: (8.25e-05, -0.000295) (8.2461478e-05, -0.00029578414) (8.2346282e-05, -0.00029656072) (8.2155523e-05, -0.00029732228) (8.1891036e-05, -0.00029806147) (8.155537e-05, -0.00029877117) (8.1151757e-05, -0.00029944456) (8.0684084e-05, -0.00030007515) (8.0156854e-05, -0.00030065685) (7.9575146e-05, -0.00030118408) (7.8944562e-05, -0.00030165176) (7.8271174e-05, -0.00030205537) (7.7561467e-05, -0.00030239104) (7.6822277e-05, -0.00030265552) (7.6060723e-05, -0.00030284628) (7.5284137e-05, -0.00030296148) (7.45e-05, -0.000303) (-7.45e-05, -0.000303) (-7.5284137e-05, -0.00030296148) (-7.6060723e-05, -0.00030284628) (-7.6822277e-05, -0.00030265552) (-7.7561467e-05, -0.00030239104) (-7.8271174e-05, -0.00030205537) (-7.8944562e-05, -0.00030165176) (-7.9575146e-05, -0.00030118408) (-8.0156854e-05, -0.00030065685) (-8.0684084e-05, -0.00030007515) (-8.1151757e-05, -0.00029944456) (-8.155537e-05, -0.00029877117) (-8.1891036e-05, -0.00029806147) (-8.2155523e-05, -0.00029732228) (-8.2346282e-05, -0.00029656072) (-8.2461478e-05, -0.00029578414) (-8.25e-05, -0.000295) (-8.25e-05, -0.00027) (-8.2461478e-05, -0.00026921586) (-8.2346282e-05, -0.00026843928) (-8.2155523e-05, -0.00026767772) (-8.1891036e-05, -0.00026693853) (-8.155537e-05, -0.00026622883) (-8.1151757e-05, -0.00026555544) (-8.0684084e-05, -0.00026492485) (-8.0156854e-05, -0.00026434315) (-7.9575146e-05, -0.00026381592) (-7.8944562e-05, -0.00026334824) (-7.8271174e-05, -0.00026294463) (-7.7561467e-05, -0.00026260896) (-7.6822277e-05, -0.00026234448) (-7.6060723e-05, -0.00026215372) (-7.5284137e-05, -0.00026203852) (-7.45e-05, -0.000262) (7.45e-05, -0.000262) (7.5284137e-05, -0.00026203852) (7.6060723e-05, -0.00026215372) (7.6822277e-05, -0.00026234448) (7.7561467e-05, -0.00026260896) (7.8271174e-05, -0.00026294463) (7.8944562e-05, -0.00026334824) (7.9575146e-05, -0.00026381592) (8.0156854e-05, -0.00026434315) (8.0684084e-05, -0.00026492485) (8.1151757e-05, -0.00026555544) (8.155537e-05, -0.00026622883) (8.1891036e-05, -0.00026693853) (8.2155523e-05, -0.00026767772) (8.2346282e-05, -0.00026843928) (8.2461478e-05, -0.00026921586) (8.25e-05, -0.00027) (8.25e-05, -0.000295), closed, covered)
  frame_cp_ch3 = polyline(z=0, xy: (8.25e-05, -0.000311) (8.3284137e-05, -0.00031096148) (8.4060723e-05, -0.00031084628) (8.4822277e-05, -0.00031065552) (8.5561467e-05, -0.00031039104) (8.6271174e-05, -0.00031005537) (8.6944562e-05, -0.00030965176) (8.7575146e-05, -0.00030918408) (8.8156854e-05, -0.00030865685) (8.8684084e-05, -0.00030807515) (8.9151757e-05, -0.00030744456) (8.955537e-05, -0.00030677117) (8.9891036e-05, -0.00030606147) (9.0155523e-05, -0.00030532228) (9.0346282e-05, -0.00030456072) (9.0461478e-05, -0.00030378414) (9.05e-05, -0.000303) (9.05e-05, -0.000262) (9.0461478e-05, -0.00026121586) (9.0346282e-05, -0.00026043928) (9.0155523e-05, -0.00025967772) (8.9891036e-05, -0.00025893853) (8.955537e-05, -0.00025822883) (8.9151757e-05, -0.00025755544) (8.8684084e-05, -0.00025692485) (8.8156854e-05, -0.00025634315) (8.7575146e-05, -0.00025581592) (8.6944562e-05, -0.00025534824) (8.6271174e-05, -0.00025494463) (8.5561467e-05, -0.00025460896) (8.4822277e-05, -0.00025434448) (8.4060723e-05, -0.00025415372) (8.3284137e-05, -0.00025403852) (8.25e-05, -0.000254) (1.909818e-05, -0.000254) (1.8901939e-05, -0.00025399518) (1.8412015e-05, -0.00025397111) (1.80216e-05, -0.00025393266) (1.7633541e-05, -0.0002538751) (1.7248774e-05, -0.00025379856) (1.6868226e-05, -0.00025370324) (1.6492814e-05, -0.00025358936) (1.6123441e-05, -0.0002534572) (1.5760999e-05, -0.00025330707) (1.540636e-05, -0.00025313934) (1.5060378e-05, -0.00025295441) (1.4723887e-05, -0.00025275272) (1.4397697e-05, -0.00025253477) (1.4082595e-05, -0.00025230107) (1.3779339e-05, -0.0002520522) (1.348866e-05, -0.00025178874) (1.3211259e-05, -0.00025151134) (1.2947803e-05, -0.00025122066) (1.2698928e-05, -0.0002509174) (1.2465232e-05, -0.0002506023) (1.2247279e-05, -0.00025027611) (1.2045594e-05, -0.00024993962) (1.1860663e-05, -0.00024959364) (1.1692931e-05, -0.000249239) (1.1542802e-05, -0.00024887656) (1.1410639e-05, -0.00024850719) (1.1296759e-05, -0.00024813177) (1.1201436e-05, -0.00024775123) (1.1124902e-05, -0.00024736646) (1.1067338e-05, -0.0002469784) (1.1028886e-05, -0.00024658799) (1.1004817e-05, -0.00024609806) (1.1e-05, -0.00024590182) (1.1e-05, -0.00019809818) (1.1004817e-05, -0.00019790194) (1.1028886e-05, -0.00019741201) (1.1067338e-05, -0.0001970216) (1.1124902e-05, -0.00019663354) (1.1201436e-05, -0.00019624877) (1.1296759e-05, -0.00019586823) (1.1410639e-05, -0.00019549281) (1.1542802e-05, -0.00019512344) (1.1692931e-05, -0.000194761) (1.1860663e-05, -0.00019440636) (1.2045594e-05, -0.00019406038) (1.2247279e-05, -0.00019372389) (1.2465232e-05, -0.0001933977) (1.2698928e-05, -0.00019308259) (1.2947803e-05, -0.00019277934) (1.3211259e-05, -0.00019248866) (1.348866e-05, -0.00019221126) (1.3779339e-05, -0.0001919478) (1.4082595e-05, -0.00019169893) (1.4397697e-05, -0.00019146523) (1.4723887e-05, -0.00019124728) (1.5060378e-05, -0.00019104559) (1.540636e-05, -0.00019086066) (1.5760999e-05, -0.00019069293) (1.6123441e-05, -0.0001905428) (1.6492814e-05, -0.00019041064) (1.6868226e-05, -0.00019029676) (1.7248774e-05, -0.00019020144) (1.7633541e-05, -0.0001901249) (1.80216e-05, -0.00019006734) (1.8412015e-05, -0.00019002889) (1.8901939e-05, -0.00019000482) (1.909818e-05, -0.00019) (0.00013940182, -0.00019) (0.00013959806, -0.00019000482) (0.00014008798, -0.00019002889) (0.0001404784, -0.00019006734) (0.00014086646, -0.0001901249) (0.00014125123, -0.00019020144) (0.00014163177, -0.00019029676) (0.00014200719, -0.00019041064) (0.00014237656, -0.0001905428) (0.000142739, -0.00019069293) (0.00014309364, -0.00019086066) (0.00014343962, -0.00019104559) (0.00014377611, -0.00019124728) (0.0001441023, -0.00019146523) (0.0001444174, -0.00019169893) (0.00014472066, -0.0001919478) (0.00014501134, -0.00019221126) (0.00014528874, -0.00019248866) (0.0001455522, -0.00019277934) (0.00014580107, -0.00019308259) (0.00014603477, -0.0001933977) (0.00014625272, -0.00019372389) (0.00014645441, -0.00019406038) (0.00014663934, -0.00019440636) (0.00014680707, -0.000194761) (0.0001469572, -0.00019512344) (0.00014708936, -0.00019549281) (0.00014720324, -0.00019586823) (0.00014729856, -0.00019624877) (0.0001473751, -0.00019663354) (0.00014743266, -0.0001970216) (0.00014747111, -0.00019741201) (0.00014749518, -0.00019790194) (0.0001475, -0.00019809818) (0.0001475, -0.00035490182) (0.00014749518, -0.00035509806) (0.00014747111, -0.00035558799) (0.00014743266, -0.0003559784) (0.0001473751, -0.00035636646) (0.00014729856, -0.00035675123) (0.00014720324, -0.00035713177) (0.00014708936, -0.00035750719) (0.0001469572, -0.00035787656) (0.00014680707, -0.000358239) (0.00014663934, -0.00035859364) (0.00014645441, -0.00035893962) (0.00014625272, -0.00035927611) (0.00014603477, -0.0003596023) (0.00014580107, -0.00035991741) (0.0001455522, -0.00036022066) (0.00014528874, -0.00036051134) (0.00014501134, -0.00036078874) (0.00014472066, -0.0003610522) (0.0001444174, -0.00036130107) (0.0001441023, -0.00036153477) (0.00014377611, -0.00036175272) (0.00014343962, -0.00036195441) (0.00014309364, -0.00036213934) (0.000142739, -0.00036230707) (0.00014237656, -0.0003624572) (0.00014200719, -0.00036258936) (0.00014163177, -0.00036270324) (0.00014125123, -0.00036279856) (0.00014086646, -0.0003628751) (0.0001404784, -0.00036293266) (0.00014008798, -0.00036297111) (0.00013959806, -0.00036299518) (0.00013940182, -0.000363) (-0.00013940182, -0.000363) (-0.00013959806, -0.00036299518) (-0.00014008798, -0.00036297111) (-0.0001404784, -0.00036293266) (-0.00014086646, -0.0003628751) (-0.00014125123, -0.00036279856) (-0.00014163177, -0.00036270324) (-0.00014200719, -0.00036258936) (-0.00014237656, -0.0003624572) (-0.000142739, -0.00036230707) (-0.00014309364, -0.00036213934) (-0.00014343962, -0.00036195441) (-0.00014377611, -0.00036175272) (-0.0001441023, -0.00036153477) (-0.0001444174, -0.00036130107) (-0.00014472066, -0.0003610522) (-0.00014501134, -0.00036078874) (-0.00014528874, -0.00036051134) (-0.0001455522, -0.00036022066) (-0.00014580107, -0.00035991741) (-0.00014603477, -0.0003596023) (-0.00014625272, -0.00035927611) (-0.00014645441, -0.00035893962) (-0.00014663934, -0.00035859364) (-0.00014680707, -0.000358239) (-0.0001469572, -0.00035787656) (-0.00014708936, -0.00035750719) (-0.00014720324, -0.00035713177) (-0.00014729856, -0.00035675123) (-0.0001473751, -0.00035636646) (-0.00014743266, -0.0003559784) (-0.00014747111, -0.00035558799) (-0.00014749518, -0.00035509806) (-0.0001475, -0.00035490182) (-0.0001475, -0.00019809818) (-0.00014749518, -0.00019790194) (-0.00014747111, -0.00019741201) (-0.00014743266, -0.0001970216) (-0.0001473751, -0.00019663354) (-0.00014729856, -0.00019624877) (-0.00014720324, -0.00019586823) (-0.00014708936, -0.00019549281) (-0.0001469572, -0.00019512344) (-0.00014680707, -0.000194761) (-0.00014663934, -0.00019440636) (-0.00014645441, -0.00019406038) (-0.00014625272, -0.00019372389) (-0.00014603477, -0.0001933977) (-0.00014580107, -0.00019308259) (-0.0001455522, -0.00019277934) (-0.00014528874, -0.00019248866) (-0.00014501134, -0.00019221126) (-0.00014472066, -0.0001919478) (-0.0001444174, -0.00019169893) (-0.0001441023, -0.00019146523) (-0.00014377611, -0.00019124728) (-0.00014343962, -0.00019104559) (-0.00014309364, -0.00019086066) (-0.000142739, -0.00019069293) (-0.00014237656, -0.0001905428) (-0.00014200719, -0.00019041064) (-0.00014163177, -0.00019029676) (-0.00014125123, -0.00019020144) (-0.00014086646, -0.0001901249) (-0.0001404784, -0.00019006734) (-0.00014008798, -0.00019002889) (-0.00013959806, -0.00019000482) (-0.00013940182, -0.00019) (-1.909818e-05, -0.00019) (-1.8901939e-05, -0.00019000482) (-1.8412015e-05, -0.00019002889) (-1.80216e-05, -0.00019006734) (-1.7633541e-05, -0.0001901249) (-1.7248774e-05, -0.00019020144) (-1.6868226e-05, -0.00019029676) (-1.6492814e-05, -0.00019041064) (-1.6123441e-05, -0.0001905428) (-1.5760999e-05, -0.00019069293) (-1.540636e-05, -0.00019086066) (-1.5060378e-05, -0.00019104559) (-1.4723887e-05, -0.00019124728) (-1.4397697e-05, -0.00019146523) (-1.4082595e-05, -0.00019169893) (-1.3779339e-05, -0.0001919478) (-1.348866e-05, -0.00019221126) (-1.3211259e-05, -0.00019248866) (-1.2947803e-05, -0.00019277934) (-1.2698928e-05, -0.00019308259) (-1.2465232e-05, -0.0001933977) (-1.2247279e-05, -0.00019372389) (-1.2045594e-05, -0.00019406038) (-1.1860663e-05, -0.00019440636) (-1.1692931e-05, -0.000194761) (-1.1542802e-05, -0.00019512344) (-1.1410639e-05, -0.00019549281) (-1.1296759e-05, -0.00019586823) (-1.1201436e-05, -0.00019624877) (-1.1124902e-05, -0.00019663354) (-1.1067338e-05, -0.0001970216) (-1.1028886e-05, -0.00019741201) (-1.1004817e-05, -0.00019790194) (-1.1e-05, -0.00019809818) (-1.1e-05, -0.00024590182) (-1.1004817e-05, -0.00024609806) (-1.1028886e-05, -0.00024658799) (-1.1067338e-05, -0.0002469784) (-1.1124902e-05, -0.00024736646) (-1.1201436e-05, -0.00024775123) (-1.1296759e-05, -0.00024813177) (-1.1410639e-05, -0.00024850719) (-1.1542802e-05, -0.00024887656) (-1.1692931e-05, -0.000249239) (-1.1860663e-05, -0.00024959364) (-1.2045594e-05, -0.00024993962) (-1.2247279e-05, -0.00025027611) (-1.2465232e-05, -0.0002506023) (-1.2698928e-05, -0.0002509174) (-1.2947803e-05, -0.00025122066) (-1.3211259e-05, -0.00025151134) (-1.348866e-05, -0.00025178874) (-1.3779339e-05, -0.0002520522) (-1.4082595e-05, -0.00025230107) (-1.4397697e-05, -0.00025253477) (-1.4723887e-05, -0.00025275272) (-1.5060378e-05, -0.00025295441) (-1.540636e-05, -0.00025313934) (-1.5760999e-05, -0.00025330707) (-1.6123441e-05, -0.0002534572) (-1.6492814e-05, -0.00025358936) (-1.6868226e-05, -0.00025370324)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, closed, covered)
  pocket_cp_ch3 = polyline(z=0, xy: (0.0001475, -0.000375) (-0.0001475, -0.000375) (-0.00014867621, -0.00037494222) (-0.00014984108, -0.00037476942) (-0.00015098342, -0.00037448328) (-0.0001520922, -0.00037408655) (-0.00015315676, -0.00037358305) (-0.00015416684, -0.00037297763) (-0.00015511272, -0.00037227612) (-0.00015598528, -0.00037148528) (-0.00015677613, -0.00037061272) (-0.00015747764, -0.00036966684) (-0.00015808305, -0.00036865676) (-0.00015858655, -0.0003675922) (-0.00015898328, -0.00036648342) (-0.00015926942, -0.00036534108) (-0.00015944222, -0.00036417621) (-0.0001595, -0.000363) (-0.0001595, -0.00019) (-0.00015944222, -0.00018882379) (-0.00015926942, -0.00018765892) (-0.00015898328, -0.00018651658) (-0.00015858655, -0.0001854078) (-0.00015808305, -0.00018434324) (-0.00015747764, -0.00018333316) (-0.00015677613, -0.00018238728) (-0.00015598528, -0.00018151472) (-0.00015511272, -0.00018072388) (-0.00015416684, -0.00018002237) (-0.00015315676, -0.00017941694) (-0.0001520922, -0.00017891345) (-0.00015098342, -0.00017851672) (-0.00014984108, -0.00017823058) (-0.00014867621, -0.00017805778) (-0.0001475, -0.000178) (0.0001475, -0.000178) (0.00014867621, -0.00017805778) (0.00014984108, -0.00017823058) (0.00015098342, -0.00017851672) (0.0001520922, -0.00017891345) (0.00015315676, -0.00017941694) (0.00015416684, -0.00018002237) (0.00015511272, -0.00018072388) (0.00015598528, -0.00018151472) (0.00015677613, -0.00018238728) (0.00015747764, -0.00018333316) (0.00015808305, -0.00018434324) (0.00015858655, -0.0001854078) (0.00015898328, -0.00018651658) (0.00015926942, -0.00018765892) (0.00015944222, -0.00018882379) (0.0001595, -0.00019) (0.0001595, -0.000363) (0.00015944222, -0.00036417621) (0.00015926942, -0.00036534108) (0.00015898328, -0.00036648342) (0.00015858655, -0.0003675922) (0.00015808305, -0.00036865676) (0.00015747764, -0.00036966684) (0.00015677613, -0.00037061272) (0.00015598528, -0.00037148528) (0.00015511272, -0.00037227612) (0.00015416684, -0.00037297763) (0.00015315676, -0.00037358305) (0.0001520922, -0.00037408655) (0.00015098342, -0.00037448328) (0.00014984108, -0.00037476942) (0.00014867621, -0.00037494222) (0.0001475, -0.000375), closed, covered)
  tap_trace_jf_ch3 = polyline(z=0, xy: (5e-06, -0.001465) (5e-06, -0.00161) (3.55e-05, -0.00161) (3.55e-05, -0.00162) (5e-06, -0.00162) (5e-06, -0.001765) (-5e-06, -0.001765) (-5e-06, -0.001465) (5e-06, -0.001465), closed, covered)
  tap_cut_jf_ch3 = polyline(z=0, xy: (1.1e-05, -0.001465) (1.1e-05, -0.001604) (3.55e-05, -0.001604) (3.55e-05, -0.001626) (1.1e-05, -0.001626) (1.1e-05, -0.001765) (-1.1e-05, -0.001765) (-1.1e-05, -0.001465) (1.1e-05, -0.001465), closed, covered)
  tap_trace_jr_ch3 = polyline(z=0, xy: (0.0001645, -0.00161) (0.000195, -0.00161) (0.000195, -0.001465) (0.000205, -0.001465) (0.000205, -0.001765) (0.000195, -0.001765) (0.000195, -0.00162) (0.0001645, -0.00162) (0.0001645, -0.00161), closed, covered)
  tap_cut_jr_ch3 = polyline(z=0, xy: (0.0001645, -0.001604) (0.000189, -0.001604) (0.000189, -0.001465) (0.000211, -0.001465) (0.000211, -0.001765) (0.000189, -0.001765) (0.000189, -0.001626) (0.0001645, -0.001626) (0.0001645, -0.001604), closed, covered)
  head_a_cj_ch3 = polyline(z=0, xy: (6.75e-05, -0.0016475) (6.7303966e-05, -0.0016474904) (6.7109819e-05, -0.0016474616) (6.6919431e-05, -0.0016474139) (6.6734633e-05, -0.0016473478) (6.6557207e-05, -0.0016472638) (6.638886e-05, -0.0016471629) (6.6231213e-05, -0.001647046) (6.6085786e-05, -0.0016469142) (6.5953979e-05, -0.0016467688) (6.5837061e-05, -0.0016466111) (6.5736157e-05, -0.0016464428) (6.5652241e-05, -0.0016462654) (6.5586119e-05, -0.0016460806) (6.5538429e-05, -0.0016458902) (6.5509631e-05, -0.001645696) (6.55e-05, -0.0016455) (6.55e-05, -0.0015845) (6.5509631e-05, -0.001584304) (6.5538429e-05, -0.0015841098) (6.5586119e-05, -0.0015839194) (6.5652241e-05, -0.0015837346) (6.5736157e-05, -0.0015835572) (6.5837061e-05, -0.0015833889) (6.5953979e-05, -0.0015832312) (6.6085786e-05, -0.0015830858) (6.6231213e-05, -0.001582954) (6.638886e-05, -0.0015828371) (6.6557207e-05, -0.0015827362) (6.6734633e-05, -0.0015826522) (6.6919431e-05, -0.0015825861) (6.7109819e-05, -0.0015825384) (6.7303966e-05, -0.0015825096) (6.75e-05, -0.0015825) (8.85e-05, -0.0015825) (8.8696034e-05, -0.0015825096) (8.8890181e-05, -0.0015825384) (8.9080569e-05, -0.0015825861) (8.9265367e-05, -0.0015826522) (8.9442793e-05, -0.0015827362) (8.961114e-05, -0.0015828371) (8.9768787e-05, -0.001582954) (8.9914214e-05, -0.0015830858) (9.0046021e-05, -0.0015832312) (9.0162939e-05, -0.0015833889) (9.0263843e-05, -0.0015835572) (9.0347759e-05, -0.0015837346) (9.0413881e-05, -0.0015839194) (9.0461571e-05, -0.0015841098) (9.0490369e-05, -0.001584304) (9.05e-05, -0.0015845) (9.05e-05, -0.0016455) (9.0490369e-05, -0.001645696) (9.0461571e-05, -0.0016458902) (9.0413881e-05, -0.0016460806) (9.0347759e-05, -0.0016462654) (9.0263843e-05, -0.0016464428) (9.0162939e-05, -0.0016466111) (9.0046021e-05, -0.0016467688) (8.9914214e-05, -0.0016469142) (8.9768787e-05, -0.001647046) (8.961114e-05, -0.0016471629) (8.9442793e-05, -0.0016472638) (8.9265367e-05, -0.0016473478) (8.9080569e-05, -0.0016474139) (8.8890181e-05, -0.0016474616) (8.8696034e-05, -0.0016474904) (8.85e-05, -0.0016475) (6.75e-05, -0.0016475), closed, covered)
  head_b_cj_ch3 = polyline(z=0, xy: (0.0001115, -0.0016475) (0.00011130397, -0.0016474904) (0.00011110982, -0.0016474616) (0.00011091943, -0.0016474139) (0.00011073463, -0.0016473478) (0.00011055721, -0.0016472638) (0.00011038886, -0.0016471629) (0.00011023121, -0.001647046) (0.00011008579, -0.0016469142) (0.00010995398, -0.0016467688) (0.00010983706, -0.0016466111) (0.00010973616, -0.0016464428) (0.00010965224, -0.0016462654) (0.00010958612, -0.0016460806) (0.00010953843, -0.0016458902) (0.00010950963, -0.001645696) (0.0001095, -0.0016455) (0.0001095, -0.0015845) (0.00010950963, -0.001584304) (0.00010953843, -0.0015841098) (0.00010958612, -0.0015839194) (0.00010965224, -0.0015837346) (0.00010973616, -0.0015835572) (0.00010983706, -0.0015833889) (0.00010995398, -0.0015832312) (0.00011008579, -0.0015830858) (0.00011023121, -0.001582954) (0.00011038886, -0.0015828371) (0.00011055721, -0.0015827362) (0.00011073463, -0.0015826522) (0.00011091943, -0.0015825861) (0.00011110982, -0.0015825384) (0.00011130397, -0.0015825096) (0.0001115, -0.0015825) (0.0001325, -0.0015825) (0.00013269603, -0.0015825096) (0.00013289018, -0.0015825384) (0.00013308057, -0.0015825861) (0.00013326537, -0.0015826522) (0.00013344279, -0.0015827362) (0.00013361114, -0.0015828371) (0.00013376879, -0.001582954) (0.00013391421, -0.0015830858) (0.00013404602, -0.0015832312) (0.00013416294, -0.0015833889) (0.00013426384, -0.0015835572) (0.00013434776, -0.0015837346) (0.00013441388, -0.0015839194) (0.00013446157, -0.0015841098) (0.00013449037, -0.001584304) (0.0001345, -0.0015845) (0.0001345, -0.0016455) (0.00013449037, -0.001645696) (0.00013446157, -0.0016458902) (0.00013441388, -0.0016460806) (0.00013434776, -0.0016462654) (0.00013426384, -0.0016464428) (0.00013416294, -0.0016466111) (0.00013404602, -0.0016467688) (0.00013391421, -0.0016469142) (0.00013376879, -0.001647046) (0.00013361114, -0.0016471629) (0.00013344279, -0.0016472638) (0.00013326537, -0.0016473478) (0.00013308057, -0.0016474139) (0.00013289018, -0.0016474616) (0.00013269603, -0.0016474904) (0.0001325, -0.0016475) (0.0001115, -0.0016475), closed, covered)
  pocket_cj_ch3 = polyline(z=0, xy: (5.15e-05, -0.0016635) (5.1303966e-05, -0.0016634904) (5.1109819e-05, -0.0016634616) (5.0919431e-05, -0.0016634139) (5.0734633e-05, -0.0016633478) (5.0557207e-05, -0.0016632638) (5.038886e-05, -0.0016631629) (5.0231213e-05, -0.001663046) (5.0085786e-05, -0.0016629142) (4.9953979e-05, -0.0016627688) (4.9837061e-05, -0.0016626111) (4.9736157e-05, -0.0016624428) (4.9652241e-05, -0.0016622654) (4.9586119e-05, -0.0016620806) (4.9538429e-05, -0.0016618902) (4.9509631e-05, -0.001661696) (4.95e-05, -0.0016615) (4.95e-05, -0.0015685) (4.9509631e-05, -0.001568304) (4.9538429e-05, -0.0015681098) (4.9586119e-05, -0.0015679194) (4.9652241e-05, -0.0015677346) (4.9736157e-05, -0.0015675572) (4.9837061e-05, -0.0015673889) (4.9953979e-05, -0.0015672312) (5.0085786e-05, -0.0015670858) (5.0231213e-05, -0.001566954) (5.038886e-05, -0.0015668371) (5.0557207e-05, -0.0015667362) (5.0734633e-05, -0.0015666522) (5.0919431e-05, -0.0015665861) (5.1109819e-05, -0.0015665384) (5.1303966e-05, -0.0015665096) (5.15e-05, -0.0015665) (0.0001485, -0.0015665) (0.00014869603, -0.0015665096) (0.00014889018, -0.0015665384) (0.00014908057, -0.0015665861) (0.00014926537, -0.0015666522) (0.00014944279, -0.0015667362) (0.00014961114, -0.0015668371) (0.00014976879, -0.001566954) (0.00014991421, -0.0015670858) (0.00015004602, -0.0015672312) (0.00015016294, -0.0015673889) (0.00015026384, -0.0015675572) (0.00015034776, -0.0015677346) (0.00015041388, -0.0015679194) (0.00015046157, -0.0015681098) (0.00015049037, -0.001568304) (0.0001505, -0.0015685) (0.0001505, -0.0016615) (0.00015049037, -0.001661696) (0.00015046157, -0.0016618902) (0.00015041388, -0.0016620806) (0.00015034776, -0.0016622654) (0.00015026384, -0.0016624428) (0.00015016294, -0.0016626111) (0.00015004602, -0.0016627688) (0.00014991421, -0.0016629142) (0.00014976879, -0.001663046) (0.00014961114, -0.0016631629) (0.00014944279, -0.0016632638) (0.00014926537, -0.0016633478) (0.00014908057, -0.0016634139) (0.00014889018, -0.0016634616) (0.00014869603, -0.0016634904) (0.0001485, -0.0016635) (5.15e-05, -0.0016635), closed, covered)
  endcap_res_a_ch3_start = rectangle(corner=(0.000189, -0.002921, 0), x_size=2.2e-05, y_size=6e-06)
  endcap_feed_in_start = rectangle(corner=(-0.001176, -1.1e-05, 0), x_size=6e-06, y_size=2.2e-05)
  endcap_feed_out_end = rectangle(corner=(0.00117, -1.1e-05, 0), x_size=6e-06, y_size=2.2e-05)
  ground_main_plane = rectangle(corner=(-0.00137, -0.003115, 0), x_size=0.00274, y_size=0.003326)
  main [silicon] = box(corner=(-0.00137, -0.003115, -0.000525), size=(0.00274, 0.003326, 0.000525))
  sample_holder [vacuum] = box(corner=(-0.00137, -0.003115, -0.00165), size=(0.00274, 0.003326, 0.00254))
  ground_main_plane.subtract(cut_stub_f_ch3, lead_a_sub_cj_ch3, lead_b_sub_cp_ch3, pocket_cp_ch3, cut_res_a_ch3, cut_feed_in, cut_feed_jf_ch3, cut_filt_ch3, tap_cut_jr_ch3, endcap_feed_out_end, tap_cut_jf_ch3, lead_a_sub_cp_ch3, cut_stub_p_ch3, endcap_res_a_ch3_start, lead_b_sub_cj_ch3, endcap_feed_in_start, cut_feed_out, pocket_cj_ch3, cut_stub_r_ch3, tap_cut_n0_ch3, cut_res_ch3)
  Port_feed_in_start = rectangle(corner=(-0.001176, -5e-06, 0), x_size=6e-06, y_size=1e-05)
  voltage_line_Port_feed_in_start = polyline((-0.00117, 0, 0) (-0.001176, 0, 0))
  Port_feed_out_end = rectangle(corner=(0.00117, -5e-06, 0), x_size=6e-06, y_size=1e-05)
  voltage_line_Port_feed_out_end = polyline((0.00117, 0, 0) (0.001176, 0, 0))
boundaries and excitations:
  PerfE: Perfect E Objects=[lead_a_cp_ch3, lead_b_cp_ch3, trace_stub_p_ch3, trace_feed_jf_ch3, lead_a_cj_ch3, lead_b_cj_ch3, trace_stub_f_ch3, trace_stub_r_ch3, trace_res_a_ch3, trace_filt_ch3, trace_res_ch3, trace_feed_in, trace_feed_out, tap_trace_n0_ch3, plate_cp_ch3, frame_cp_ch3, tap_trace_jf_ch3, tap_trace_jr_ch3, head_a_cj_ch3, head_b_cj_ch3, ground_main_plane]
  LumpPort_feed_in_start: Lumped Port Objects=Port_feed_in_start Modes{Mode1{IntLine{middle of Port_feed_in_start.edge(x at corner) -> middle of Port_feed_in_start.edge(x opposite corner)} CharImp=Zpi RenormImp=50ohm}} Impedance=50ohm
  LumpPort_feed_out_end: Lumped Port Objects=Port_feed_out_end Modes{Mode1{IntLine{middle of Port_feed_out_end.edge(x at corner) -> middle of Port_feed_out_end.edge(x opposite corner)} CharImp=Zpi RenormImp=50ohm}} Impedance=50ohm
setups:
  Setup: HfssDriven Frequency=6.71GHz MaxDeltaS=0.003 MaximumPasses=1 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=10 BasisOrder=2 PortAccuracy=2
    sweep Sweep: 6.5GHz to 6.95GHz, 1801 points; Type=Fast
source amplitudes:
  LumpPort_feed_in_start:1: 1W 0deg
  LumpPort_feed_out_end:1: 0W 0deg
field plots:
  Mesh1: MeshPlots in main on Setup : LastAdaptive at Freq=6.71GHz Phase=0deg
reports:
  S Parameter Plot 1: dB(S(LumpPort_feed_in_start,LumpPort_feed_in_start)), dB(S(LumpPort_feed_out_end,LumpPort_feed_in_start)), dB(S(LumpPort_feed_in_start,LumpPort_feed_out_end)), dB(S(LumpPort_feed_out_end,LumpPort_feed_out_end)) vs Freq on Setup : Sweep

design v6_full_1604_hfss (HFSS, DrivenModal, model units mm)
geometry:
  lead_a_cp_ch3_path = polyline((0, -0.000362999, 0) (0, -0.000415, 0))
  lead_a_cp_ch3 = polyline((5e-06, -0.000362999, 0) (-5e-06, -0.000362999, 0))
  lead_a_cp_ch3.sweep_along_path(lead_a_cp_ch3_path)
  lead_a_sub_cp_ch3_path = polyline((0, -0.000362999, 0) (0, -0.000415, 0))
  lead_a_sub_cp_ch3 = polyline((1.1e-05, -0.000362999, 0) (-1.1e-05, -0.000362999, 0))
  lead_a_sub_cp_ch3.sweep_along_path(lead_a_sub_cp_ch3_path)
  lead_b_cp_ch3_path = polyline((0, -0.000262001, 0) (0, -0.00015, 0))
  lead_b_cp_ch3 = polyline((-5e-06, -0.000262001, 0) (5e-06, -0.000262001, 0))
  lead_b_cp_ch3.sweep_along_path(lead_b_cp_ch3_path)
  lead_b_sub_cp_ch3_path = polyline((0, -0.000262001, 0) (0, -0.00015, 0))
  lead_b_sub_cp_ch3 = polyline((-1.1e-05, -0.000262001, 0) (1.1e-05, -0.000262001, 0))
  lead_b_sub_cp_ch3.sweep_along_path(lead_b_sub_cp_ch3_path)
  trace_stub_p_ch3_path = polyline((0, -0.0001, 0) (0, -0.00015, 0))
  trace_stub_p_ch3 = polyline((5e-06, -0.0001, 0) (-5e-06, -0.0001, 0))
  trace_stub_p_ch3.sweep_along_path(trace_stub_p_ch3_path)
  cut_stub_p_ch3_path = polyline((0, -0.0001, 0) (0, -0.00015, 0))
  cut_stub_p_ch3 = polyline((1.1e-05, -0.0001, 0) (-1.1e-05, -0.0001, 0))
  cut_stub_p_ch3.sweep_along_path(cut_stub_p_ch3_path)
  trace_feed_jf_ch3_path = polyline((0, -0.000415, 0) (0, -0.001465, 0))
  trace_feed_jf_ch3 = polyline((5e-06, -0.000415, 0) (-5e-06, -0.000415, 0))
  trace_feed_jf_ch3.sweep_along_path(trace_feed_jf_ch3_path)
  cut_feed_jf_ch3_path = polyline((0, -0.000415, 0) (0, -0.001465, 0))
  cut_feed_jf_ch3 = polyline((1.1e-05, -0.000415, 0) (-1.1e-05, -0.000415, 0))
  cut_feed_jf_ch3.sweep_along_path(cut_feed_jf_ch3_path)
  lead_a_cj_ch3_path = polyline((6.5501e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  lead_a_cj_ch3 = polyline((6.5501e-05, -0.00162, 0) (6.5501e-05, -0.00161, 0))
  lead_a_cj_ch3.sweep_along_path(lead_a_cj_ch3_path)
  lead_a_sub_cj_ch3_path = polyline((6.5501e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  lead_a_sub_cj_ch3 = polyline((6.5501e-05, -0.001626, 0) (6.5501e-05, -0.001604, 0))
  lead_a_sub_cj_ch3.sweep_along_path(lead_a_sub_cj_ch3_path)
  lead_b_cj_ch3_path = polyline((0.000134499, -0.001615, 0) (0.0001445, -0.001615, 0))
  lead_b_cj_ch3 = polyline((0.000134499, -0.00161, 0) (0.000134499, -0.00162, 0))
  lead_b_cj_ch3.sweep_along_path(lead_b_cj_ch3_path)
  lead_b_sub_cj_ch3_path = polyline((0.000134499, -0.001615, 0) (0.0001445, -0.001615, 0))
  lead_b_sub_cj_ch3 = polyline((0.000134499, -0.001604, 0) (0.000134499, -0.001626, 0))
  lead_b_sub_cj_ch3.sweep_along_path(lead_b_sub_cj_ch3_path)
  trace_stub_f_ch3_path = polyline((3.55e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  trace_stub_f_ch3 = polyline((3.55e-05, -0.00161, 0) (3.55e-05, -0.00162, 0))
  trace_stub_f_ch3.sweep_along_path(trace_stub_f_ch3_path)
  cut_stub_f_ch3_path = polyline((3.55e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  cut_stub_f_ch3 = polyline((3.55e-05, -0.001604, 0) (3.55e-05, -0.001626, 0))
  cut_stub_f_ch3.sweep_along_path(cut_stub_f_ch3_path)
  trace_stub_r_ch3_path = polyline((0.0001645, -0.001615, 0) (0.0001445, -0.001615, 0))
  trace_stub_r_ch3 = polyline((0.0001645, -0.00162, 0) (0.0001645, -0.00161, 0))
  trace_stub_r_ch3.sweep_along_path(trace_stub_r_ch3_path)
  cut_stub_r_ch3_path = polyline((0.0001645, -0.001615, 0) (0.0001445, -0.001615, 0))
  cut_stub_r_ch3 = polyline((0.0001645, -0.001626, 0) (0.0001645, -0.001604, 0))
  cut_stub_r_ch3.sweep_along_path(cut_stub_r_ch3_path)
  trace_res_a_ch3_path = polyline((0.0002, -0.002915, 0) (0.0002, -0.001765, 0))
  trace_res_a_ch3 = polyline((0.000195, -0.002915, 0) (0.000205, -0.002915, 0))
  trace_res_a_ch3.sweep_along_path(trace_res_a_ch3_path)
  cut_res_a_ch3_path = polyline((0.0002, -0.002915, 0) (0.0002, -0.001765, 0))
  cut_res_a_ch3 = polyline((0.000189, -0.002915, 0) (0.000211, -0.002915, 0))
  cut_res_a_ch3.sweep_along_path(cut_res_a_ch3_path)
  trace_filt_ch3_path = polyline(z=0, xy: (-0.0003, -0.000915) (-0.0003, -0.0022822498) (0, -0.0022822498) (0, -0.001765))
  trace_filt_ch3_path.fillet(Vertices=trace_filt_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  trace_filt_ch3 = polyline((-0.000295, -0.000915, 0) (-0.000305, -0.000915, 0))
  trace_filt_ch3.sweep_along_path(trace_filt_ch3_path)
  cut_filt_ch3_path = polyline(z=0, xy: (-0.0003, -0.000915) (-0.0003, -0.0022822498) (0, -0.0022822498) (0, -0.001765))
  cut_filt_ch3_path.fillet(Vertices=cut_filt_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  cut_filt_ch3 = polyline((-0.000289, -0.000915, 0) (-0.000311, -0.000915, 0))
  cut_filt_ch3.sweep_along_path(cut_filt_ch3_path)
  trace_res_ch3_path = polyline(z=0, xy: (0.00055, -0.00255234) (0.00055, -0.000665) (0.0002, -0.000665) (0.0002, -0.001465))
  trace_res_ch3_path.fillet(Vertices=trace_res_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  trace_res_ch3 = polyline((0.000545, -0.00255234, 0) (0.000555, -0.00255234, 0))
  trace_res_ch3.sweep_along_path(trace_res_ch3_path)
  cut_res_ch3_path = polyline(z=0, xy: (0.00055, -0.00255234) (0.00055, -0.000665) (0.0002, -0.000665) (0.0002, -0.001465))
  cut_res_ch3_path.fillet(Vertices=cut_res_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  cut_res_ch3 = polyline((0.000539, -0.00255234, 0) (0.000561, -0.00255234, 0))
  cut_res_ch3.sweep_along_path(cut_res_ch3_path)
  trace_feed_in_path = polyline((-0.00117, 0, 0) (-0.00015, 0, 0))
  trace_feed_in = polyline((-0.00117, 5e-06, 0) (-0.00117, -5e-06, 0))
  trace_feed_in.sweep_along_path(trace_feed_in_path)
  cut_feed_in_path = polyline((-0.00117, 0, 0) (-0.00015, 0, 0))
  cut_feed_in = polyline((-0.00117, 1.1e-05, 0) (-0.00117, -1.1e-05, 0))
  cut_feed_in.sweep_along_path(cut_feed_in_path)
  trace_feed_out_path = polyline((0.00015, 0, 0) (0.00117, 0, 0))
  trace_feed_out = polyline((0.00015, 5e-06, 0) (0.00015, -5e-06, 0))
  trace_feed_out.sweep_along_path(trace_feed_out_path)
  cut_feed_out_path = polyline((0.00015, 0, 0) (0.00117, 0, 0))
  cut_feed_out = polyline((0.00015, 1.1e-05, 0) (0.00015, -1.1e-05, 0))
  cut_feed_out.sweep_along_path(cut_feed_out_path)
  g_wb [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-5.5e-05 YPadPos=-0.000765 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_1 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-5.5e-05 YPadPos=-0.001115 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_2 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000255 YPadPos=-0.0025316667 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_3 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000255 YPadPos=-0.0021483333 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_4 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0012568124 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_5 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0015986249 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_6 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0019404373 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_7 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=5.5e-05 YPadPos=-0.0020236249 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_8 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.002174872 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_9 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001797404 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_10 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001419936 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_11 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001042468 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_12 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000145 YPadPos=-0.00093166667 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_13 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000145 YPadPos=-0.0011983333 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_14 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00083 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_15 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00049 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_16 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00049 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_17 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00083 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  tap_trace_n0_ch3 = polyline(z=0, xy: (-5e-06, -0.0001) (-5e-06, -5e-06) (-0.00015, -5e-06) (-0.00015, 5e-06) (0.00015, 5e-06) (0.00015, -5e-06) (5e-06, -5e-06) (5e-06, -0.0001) (-5e-06, -0.0001), closed, covered)
  tap_cut_n0_ch3 = polyline(z=0, xy: (-1.1e-05, -0.0001) (-1.1e-05, -1.1e-05) (-0.00015, -1.1e-05) (-0.00015, 1.1e-05) (0.00015, 1.1e-05) (0.00015, -1.1e-05) (1.1e-05, -1.1e-05) (1.1e-05, -0.0001) (-1.1e-05, -0.0001), closed, covered)
  plate_cp_ch3 = polyline(z=0, xy: (8.25e-05, -0.000295) (8.2461478e-05, -0.00029578414) (8.2346282e-05, -0.00029656072) (8.2155523e-05, -0.00029732228) (8.1891036e-05, -0.00029806147) (8.155537e-05, -0.00029877117) (8.1151757e-05, -0.00029944456) (8.0684084e-05, -0.00030007515) (8.0156854e-05, -0.00030065685) (7.9575146e-05, -0.00030118408) (7.8944562e-05, -0.00030165176) (7.8271174e-05, -0.00030205537) (7.7561467e-05, -0.00030239104) (7.6822277e-05, -0.00030265552) (7.6060723e-05, -0.00030284628) (7.5284137e-05, -0.00030296148) (7.45e-05, -0.000303) (-7.45e-05, -0.000303) (-7.5284137e-05, -0.00030296148) (-7.6060723e-05, -0.00030284628) (-7.6822277e-05, -0.00030265552) (-7.7561467e-05, -0.00030239104) (-7.8271174e-05, -0.00030205537) (-7.8944562e-05, -0.00030165176) (-7.9575146e-05, -0.00030118408) (-8.0156854e-05, -0.00030065685) (-8.0684084e-05, -0.00030007515) (-8.1151757e-05, -0.00029944456) (-8.155537e-05, -0.00029877117) (-8.1891036e-05, -0.00029806147) (-8.2155523e-05, -0.00029732228) (-8.2346282e-05, -0.00029656072) (-8.2461478e-05, -0.00029578414) (-8.25e-05, -0.000295) (-8.25e-05, -0.00027) (-8.2461478e-05, -0.00026921586) (-8.2346282e-05, -0.00026843928) (-8.2155523e-05, -0.00026767772) (-8.1891036e-05, -0.00026693853) (-8.155537e-05, -0.00026622883) (-8.1151757e-05, -0.00026555544) (-8.0684084e-05, -0.00026492485) (-8.0156854e-05, -0.00026434315) (-7.9575146e-05, -0.00026381592) (-7.8944562e-05, -0.00026334824) (-7.8271174e-05, -0.00026294463) (-7.7561467e-05, -0.00026260896) (-7.6822277e-05, -0.00026234448) (-7.6060723e-05, -0.00026215372) (-7.5284137e-05, -0.00026203852) (-7.45e-05, -0.000262) (7.45e-05, -0.000262) (7.5284137e-05, -0.00026203852) (7.6060723e-05, -0.00026215372) (7.6822277e-05, -0.00026234448) (7.7561467e-05, -0.00026260896) (7.8271174e-05, -0.00026294463) (7.8944562e-05, -0.00026334824) (7.9575146e-05, -0.00026381592) (8.0156854e-05, -0.00026434315) (8.0684084e-05, -0.00026492485) (8.1151757e-05, -0.00026555544) (8.155537e-05, -0.00026622883) (8.1891036e-05, -0.00026693853) (8.2155523e-05, -0.00026767772) (8.2346282e-05, -0.00026843928) (8.2461478e-05, -0.00026921586) (8.25e-05, -0.00027) (8.25e-05, -0.000295), closed, covered)
  frame_cp_ch3 = polyline(z=0, xy: (8.25e-05, -0.000311) (8.3284137e-05, -0.00031096148) (8.4060723e-05, -0.00031084628) (8.4822277e-05, -0.00031065552) (8.5561467e-05, -0.00031039104) (8.6271174e-05, -0.00031005537) (8.6944562e-05, -0.00030965176) (8.7575146e-05, -0.00030918408) (8.8156854e-05, -0.00030865685) (8.8684084e-05, -0.00030807515) (8.9151757e-05, -0.00030744456) (8.955537e-05, -0.00030677117) (8.9891036e-05, -0.00030606147) (9.0155523e-05, -0.00030532228) (9.0346282e-05, -0.00030456072) (9.0461478e-05, -0.00030378414) (9.05e-05, -0.000303) (9.05e-05, -0.000262) (9.0461478e-05, -0.00026121586) (9.0346282e-05, -0.00026043928) (9.0155523e-05, -0.00025967772) (8.9891036e-05, -0.00025893853) (8.955537e-05, -0.00025822883) (8.9151757e-05, -0.00025755544) (8.8684084e-05, -0.00025692485) (8.8156854e-05, -0.00025634315) (8.7575146e-05, -0.00025581592) (8.6944562e-05, -0.00025534824) (8.6271174e-05, -0.00025494463) (8.5561467e-05, -0.00025460896) (8.4822277e-05, -0.00025434448) (8.4060723e-05, -0.00025415372) (8.3284137e-05, -0.00025403852) (8.25e-05, -0.000254) (1.909818e-05, -0.000254) (1.8901939e-05, -0.00025399518) (1.8412015e-05, -0.00025397111) (1.80216e-05, -0.00025393266) (1.7633541e-05, -0.0002538751) (1.7248774e-05, -0.00025379856) (1.6868226e-05, -0.00025370324) (1.6492814e-05, -0.00025358936) (1.6123441e-05, -0.0002534572) (1.5760999e-05, -0.00025330707) (1.540636e-05, -0.00025313934) (1.5060378e-05, -0.00025295441) (1.4723887e-05, -0.00025275272) (1.4397697e-05, -0.00025253477) (1.4082595e-05, -0.00025230107) (1.3779339e-05, -0.0002520522) (1.348866e-05, -0.00025178874) (1.3211259e-05, -0.00025151134) (1.2947803e-05, -0.00025122066) (1.2698928e-05, -0.0002509174) (1.2465232e-05, -0.0002506023) (1.2247279e-05, -0.00025027611) (1.2045594e-05, -0.00024993962) (1.1860663e-05, -0.00024959364) (1.1692931e-05, -0.000249239) (1.1542802e-05, -0.00024887656) (1.1410639e-05, -0.00024850719) (1.1296759e-05, -0.00024813177) (1.1201436e-05, -0.00024775123) (1.1124902e-05, -0.00024736646) (1.1067338e-05, -0.0002469784) (1.1028886e-05, -0.00024658799) (1.1004817e-05, -0.00024609806) (1.1e-05, -0.00024590182) (1.1e-05, -0.00019809818) (1.1004817e-05, -0.00019790194) (1.1028886e-05, -0.00019741201) (1.1067338e-05, -0.0001970216) (1.1124902e-05, -0.00019663354) (1.1201436e-05, -0.00019624877) (1.1296759e-05, -0.00019586823) (1.1410639e-05, -0.00019549281) (1.1542802e-05, -0.00019512344) (1.1692931e-05, -0.000194761) (1.1860663e-05, -0.00019440636) (1.2045594e-05, -0.00019406038) (1.2247279e-05, -0.00019372389) (1.2465232e-05, -0.0001933977) (1.2698928e-05, -0.00019308259) (1.2947803e-05, -0.00019277934) (1.3211259e-05, -0.00019248866) (1.348866e-05, -0.00019221126) (1.3779339e-05, -0.0001919478) (1.4082595e-05, -0.00019169893) (1.4397697e-05, -0.00019146523) (1.4723887e-05, -0.00019124728) (1.5060378e-05, -0.00019104559) (1.540636e-05, -0.00019086066) (1.5760999e-05, -0.00019069293) (1.6123441e-05, -0.0001905428) (1.6492814e-05, -0.00019041064) (1.6868226e-05, -0.00019029676) (1.7248774e-05, -0.00019020144) (1.7633541e-05, -0.0001901249) (1.80216e-05, -0.00019006734) (1.8412015e-05, -0.00019002889) (1.8901939e-05, -0.00019000482) (1.909818e-05, -0.00019) (0.00013940182, -0.00019) (0.00013959806, -0.00019000482) (0.00014008798, -0.00019002889) (0.0001404784, -0.00019006734) (0.00014086646, -0.0001901249) (0.00014125123, -0.00019020144) (0.00014163177, -0.00019029676) (0.00014200719, -0.00019041064) (0.00014237656, -0.0001905428) (0.000142739, -0.00019069293) (0.00014309364, -0.00019086066) (0.00014343962, -0.00019104559) (0.00014377611, -0.00019124728) (0.0001441023, -0.00019146523) (0.0001444174, -0.00019169893) (0.00014472066, -0.0001919478) (0.00014501134, -0.00019221126) (0.00014528874, -0.00019248866) (0.0001455522, -0.00019277934) (0.00014580107, -0.00019308259) (0.00014603477, -0.0001933977) (0.00014625272, -0.00019372389) (0.00014645441, -0.00019406038) (0.00014663934, -0.00019440636) (0.00014680707, -0.000194761) (0.0001469572, -0.00019512344) (0.00014708936, -0.00019549281) (0.00014720324, -0.00019586823) (0.00014729856, -0.00019624877) (0.0001473751, -0.00019663354) (0.00014743266, -0.0001970216) (0.00014747111, -0.00019741201) (0.00014749518, -0.00019790194) (0.0001475, -0.00019809818) (0.0001475, -0.00035490182) (0.00014749518, -0.00035509806) (0.00014747111, -0.00035558799) (0.00014743266, -0.0003559784) (0.0001473751, -0.00035636646) (0.00014729856, -0.00035675123) (0.00014720324, -0.00035713177) (0.00014708936, -0.00035750719) (0.0001469572, -0.00035787656) (0.00014680707, -0.000358239) (0.00014663934, -0.00035859364) (0.00014645441, -0.00035893962) (0.00014625272, -0.00035927611) (0.00014603477, -0.0003596023) (0.00014580107, -0.00035991741) (0.0001455522, -0.00036022066) (0.00014528874, -0.00036051134) (0.00014501134, -0.00036078874) (0.00014472066, -0.0003610522) (0.0001444174, -0.00036130107) (0.0001441023, -0.00036153477) (0.00014377611, -0.00036175272) (0.00014343962, -0.00036195441) (0.00014309364, -0.00036213934) (0.000142739, -0.00036230707) (0.00014237656, -0.0003624572) (0.00014200719, -0.00036258936) (0.00014163177, -0.00036270324) (0.00014125123, -0.00036279856) (0.00014086646, -0.0003628751) (0.0001404784, -0.00036293266) (0.00014008798, -0.00036297111) (0.00013959806, -0.00036299518) (0.00013940182, -0.000363) (-0.00013940182, -0.000363) (-0.00013959806, -0.00036299518) (-0.00014008798, -0.00036297111) (-0.0001404784, -0.00036293266) (-0.00014086646, -0.0003628751) (-0.00014125123, -0.00036279856) (-0.00014163177, -0.00036270324) (-0.00014200719, -0.00036258936) (-0.00014237656, -0.0003624572) (-0.000142739, -0.00036230707) (-0.00014309364, -0.00036213934) (-0.00014343962, -0.00036195441) (-0.00014377611, -0.00036175272) (-0.0001441023, -0.00036153477) (-0.0001444174, -0.00036130107) (-0.00014472066, -0.0003610522) (-0.00014501134, -0.00036078874) (-0.00014528874, -0.00036051134) (-0.0001455522, -0.00036022066) (-0.00014580107, -0.00035991741) (-0.00014603477, -0.0003596023) (-0.00014625272, -0.00035927611) (-0.00014645441, -0.00035893962) (-0.00014663934, -0.00035859364) (-0.00014680707, -0.000358239) (-0.0001469572, -0.00035787656) (-0.00014708936, -0.00035750719) (-0.00014720324, -0.00035713177) (-0.00014729856, -0.00035675123) (-0.0001473751, -0.00035636646) (-0.00014743266, -0.0003559784) (-0.00014747111, -0.00035558799) (-0.00014749518, -0.00035509806) (-0.0001475, -0.00035490182) (-0.0001475, -0.00019809818) (-0.00014749518, -0.00019790194) (-0.00014747111, -0.00019741201) (-0.00014743266, -0.0001970216) (-0.0001473751, -0.00019663354) (-0.00014729856, -0.00019624877) (-0.00014720324, -0.00019586823) (-0.00014708936, -0.00019549281) (-0.0001469572, -0.00019512344) (-0.00014680707, -0.000194761) (-0.00014663934, -0.00019440636) (-0.00014645441, -0.00019406038) (-0.00014625272, -0.00019372389) (-0.00014603477, -0.0001933977) (-0.00014580107, -0.00019308259) (-0.0001455522, -0.00019277934) (-0.00014528874, -0.00019248866) (-0.00014501134, -0.00019221126) (-0.00014472066, -0.0001919478) (-0.0001444174, -0.00019169893) (-0.0001441023, -0.00019146523) (-0.00014377611, -0.00019124728) (-0.00014343962, -0.00019104559) (-0.00014309364, -0.00019086066) (-0.000142739, -0.00019069293) (-0.00014237656, -0.0001905428) (-0.00014200719, -0.00019041064) (-0.00014163177, -0.00019029676) (-0.00014125123, -0.00019020144) (-0.00014086646, -0.0001901249) (-0.0001404784, -0.00019006734) (-0.00014008798, -0.00019002889) (-0.00013959806, -0.00019000482) (-0.00013940182, -0.00019) (-1.909818e-05, -0.00019) (-1.8901939e-05, -0.00019000482) (-1.8412015e-05, -0.00019002889) (-1.80216e-05, -0.00019006734) (-1.7633541e-05, -0.0001901249) (-1.7248774e-05, -0.00019020144) (-1.6868226e-05, -0.00019029676) (-1.6492814e-05, -0.00019041064) (-1.6123441e-05, -0.0001905428) (-1.5760999e-05, -0.00019069293) (-1.540636e-05, -0.00019086066) (-1.5060378e-05, -0.00019104559) (-1.4723887e-05, -0.00019124728) (-1.4397697e-05, -0.00019146523) (-1.4082595e-05, -0.00019169893) (-1.3779339e-05, -0.0001919478) (-1.348866e-05, -0.00019221126) (-1.3211259e-05, -0.00019248866) (-1.2947803e-05, -0.00019277934) (-1.2698928e-05, -0.00019308259) (-1.2465232e-05, -0.0001933977) (-1.2247279e-05, -0.00019372389) (-1.2045594e-05, -0.00019406038) (-1.1860663e-05, -0.00019440636) (-1.1692931e-05, -0.000194761) (-1.1542802e-05, -0.00019512344) (-1.1410639e-05, -0.00019549281) (-1.1296759e-05, -0.00019586823) (-1.1201436e-05, -0.00019624877) (-1.1124902e-05, -0.00019663354) (-1.1067338e-05, -0.0001970216) (-1.1028886e-05, -0.00019741201) (-1.1004817e-05, -0.00019790194) (-1.1e-05, -0.00019809818) (-1.1e-05, -0.00024590182) (-1.1004817e-05, -0.00024609806) (-1.1028886e-05, -0.00024658799) (-1.1067338e-05, -0.0002469784) (-1.1124902e-05, -0.00024736646) (-1.1201436e-05, -0.00024775123) (-1.1296759e-05, -0.00024813177) (-1.1410639e-05, -0.00024850719) (-1.1542802e-05, -0.00024887656) (-1.1692931e-05, -0.000249239) (-1.1860663e-05, -0.00024959364) (-1.2045594e-05, -0.00024993962) (-1.2247279e-05, -0.00025027611) (-1.2465232e-05, -0.0002506023) (-1.2698928e-05, -0.0002509174) (-1.2947803e-05, -0.00025122066) (-1.3211259e-05, -0.00025151134) (-1.348866e-05, -0.00025178874) (-1.3779339e-05, -0.0002520522) (-1.4082595e-05, -0.00025230107) (-1.4397697e-05, -0.00025253477) (-1.4723887e-05, -0.00025275272) (-1.5060378e-05, -0.00025295441) (-1.540636e-05, -0.00025313934) (-1.5760999e-05, -0.00025330707) (-1.6123441e-05, -0.0002534572) (-1.6492814e-05, -0.00025358936) (-1.6868226e-05, -0.00025370324)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, closed, covered)
  pocket_cp_ch3 = polyline(z=0, xy: (0.0001475, -0.000375) (-0.0001475, -0.000375) (-0.00014867621, -0.00037494222) (-0.00014984108, -0.00037476942) (-0.00015098342, -0.00037448328) (-0.0001520922, -0.00037408655) (-0.00015315676, -0.00037358305) (-0.00015416684, -0.00037297763) (-0.00015511272, -0.00037227612) (-0.00015598528, -0.00037148528) (-0.00015677613, -0.00037061272) (-0.00015747764, -0.00036966684) (-0.00015808305, -0.00036865676) (-0.00015858655, -0.0003675922) (-0.00015898328, -0.00036648342) (-0.00015926942, -0.00036534108) (-0.00015944222, -0.00036417621) (-0.0001595, -0.000363) (-0.0001595, -0.00019) (-0.00015944222, -0.00018882379) (-0.00015926942, -0.00018765892) (-0.00015898328, -0.00018651658) (-0.00015858655, -0.0001854078) (-0.00015808305, -0.00018434324) (-0.00015747764, -0.00018333316) (-0.00015677613, -0.00018238728) (-0.00015598528, -0.00018151472) (-0.00015511272, -0.00018072388) (-0.00015416684, -0.00018002237) (-0.00015315676, -0.00017941694) (-0.0001520922, -0.00017891345) (-0.00015098342, -0.00017851672) (-0.00014984108, -0.00017823058) (-0.00014867621, -0.00017805778) (-0.0001475, -0.000178) (0.0001475, -0.000178) (0.00014867621, -0.00017805778) (0.00014984108, -0.00017823058) (0.00015098342, -0.00017851672) (0.0001520922, -0.00017891345) (0.00015315676, -0.00017941694) (0.00015416684, -0.00018002237) (0.00015511272, -0.00018072388) (0.00015598528, -0.00018151472) (0.00015677613, -0.00018238728) (0.00015747764, -0.00018333316) (0.00015808305, -0.00018434324) (0.00015858655, -0.0001854078) (0.00015898328, -0.00018651658) (0.00015926942, -0.00018765892) (0.00015944222, -0.00018882379) (0.0001595, -0.00019) (0.0001595, -0.000363) (0.00015944222, -0.00036417621) (0.00015926942, -0.00036534108) (0.00015898328, -0.00036648342) (0.00015858655, -0.0003675922) (0.00015808305, -0.00036865676) (0.00015747764, -0.00036966684) (0.00015677613, -0.00037061272) (0.00015598528, -0.00037148528) (0.00015511272, -0.00037227612) (0.00015416684, -0.00037297763) (0.00015315676, -0.00037358305) (0.0001520922, -0.00037408655) (0.00015098342, -0.00037448328) (0.00014984108, -0.00037476942) (0.00014867621, -0.00037494222) (0.0001475, -0.000375), closed, covered)
  tap_trace_jf_ch3 = polyline(z=0, xy: (5e-06, -0.001465) (5e-06, -0.00161) (3.55e-05, -0.00161) (3.55e-05, -0.00162) (5e-06, -0.00162) (5e-06, -0.001765) (-5e-06, -0.001765) (-5e-06, -0.001465) (5e-06, -0.001465), closed, covered)
  tap_cut_jf_ch3 = polyline(z=0, xy: (1.1e-05, -0.001465) (1.1e-05, -0.001604) (3.55e-05, -0.001604) (3.55e-05, -0.001626) (1.1e-05, -0.001626) (1.1e-05, -0.001765) (-1.1e-05, -0.001765) (-1.1e-05, -0.001465) (1.1e-05, -0.001465), closed, covered)
  tap_trace_jr_ch3 = polyline(z=0, xy: (0.0001645, -0.00161) (0.000195, -0.00161) (0.000195, -0.001465) (0.000205, -0.001465) (0.000205, -0.001765) (0.000195, -0.001765) (0.000195, -0.00162) (0.0001645, -0.00162) (0.0001645, -0.00161), closed, covered)
  tap_cut_jr_ch3 = polyline(z=0, xy: (0.0001645, -0.001604) (0.000189, -0.001604) (0.000189, -0.001465) (0.000211, -0.001465) (0.000211, -0.001765) (0.000189, -0.001765) (0.000189, -0.001626) (0.0001645, -0.001626) (0.0001645, -0.001604), closed, covered)
  head_a_cj_ch3 = polyline(z=0, xy: (6.75e-05, -0.0016475) (6.7303966e-05, -0.0016474904) (6.7109819e-05, -0.0016474616) (6.6919431e-05, -0.0016474139) (6.6734633e-05, -0.0016473478) (6.6557207e-05, -0.0016472638) (6.638886e-05, -0.0016471629) (6.6231213e-05, -0.001647046) (6.6085786e-05, -0.0016469142) (6.5953979e-05, -0.0016467688) (6.5837061e-05, -0.0016466111) (6.5736157e-05, -0.0016464428) (6.5652241e-05, -0.0016462654) (6.5586119e-05, -0.0016460806) (6.5538429e-05, -0.0016458902) (6.5509631e-05, -0.001645696) (6.55e-05, -0.0016455) (6.55e-05, -0.0015845) (6.5509631e-05, -0.001584304) (6.5538429e-05, -0.0015841098) (6.5586119e-05, -0.0015839194) (6.5652241e-05, -0.0015837346) (6.5736157e-05, -0.0015835572) (6.5837061e-05, -0.0015833889) (6.5953979e-05, -0.0015832312) (6.6085786e-05, -0.0015830858) (6.6231213e-05, -0.001582954) (6.638886e-05, -0.0015828371) (6.6557207e-05, -0.0015827362) (6.6734633e-05, -0.0015826522) (6.6919431e-05, -0.0015825861) (6.7109819e-05, -0.0015825384) (6.7303966e-05, -0.0015825096) (6.75e-05, -0.0015825) (8.85e-05, -0.0015825) (8.8696034e-05, -0.0015825096) (8.8890181e-05, -0.0015825384) (8.9080569e-05, -0.0015825861) (8.9265367e-05, -0.0015826522) (8.9442793e-05, -0.0015827362) (8.961114e-05, -0.0015828371) (8.9768787e-05, -0.001582954) (8.9914214e-05, -0.0015830858) (9.0046021e-05, -0.0015832312) (9.0162939e-05, -0.0015833889) (9.0263843e-05, -0.0015835572) (9.0347759e-05, -0.0015837346) (9.0413881e-05, -0.0015839194) (9.0461571e-05, -0.0015841098) (9.0490369e-05, -0.001584304) (9.05e-05, -0.0015845) (9.05e-05, -0.0016455) (9.0490369e-05, -0.001645696) (9.0461571e-05, -0.0016458902) (9.0413881e-05, -0.0016460806) (9.0347759e-05, -0.0016462654) (9.0263843e-05, -0.0016464428) (9.0162939e-05, -0.0016466111) (9.0046021e-05, -0.0016467688) (8.9914214e-05, -0.0016469142) (8.9768787e-05, -0.001647046) (8.961114e-05, -0.0016471629) (8.9442793e-05, -0.0016472638) (8.9265367e-05, -0.0016473478) (8.9080569e-05, -0.0016474139) (8.8890181e-05, -0.0016474616) (8.8696034e-05, -0.0016474904) (8.85e-05, -0.0016475) (6.75e-05, -0.0016475), closed, covered)
  head_b_cj_ch3 = polyline(z=0, xy: (0.0001115, -0.0016475) (0.00011130397, -0.0016474904) (0.00011110982, -0.0016474616) (0.00011091943, -0.0016474139) (0.00011073463, -0.0016473478) (0.00011055721, -0.0016472638) (0.00011038886, -0.0016471629) (0.00011023121, -0.001647046) (0.00011008579, -0.0016469142) (0.00010995398, -0.0016467688) (0.00010983706, -0.0016466111) (0.00010973616, -0.0016464428) (0.00010965224, -0.0016462654) (0.00010958612, -0.0016460806) (0.00010953843, -0.0016458902) (0.00010950963, -0.001645696) (0.0001095, -0.0016455) (0.0001095, -0.0015845) (0.00010950963, -0.001584304) (0.00010953843, -0.0015841098) (0.00010958612, -0.0015839194) (0.00010965224, -0.0015837346) (0.00010973616, -0.0015835572) (0.00010983706, -0.0015833889) (0.00010995398, -0.0015832312) (0.00011008579, -0.0015830858) (0.00011023121, -0.001582954) (0.00011038886, -0.0015828371) (0.00011055721, -0.0015827362) (0.00011073463, -0.0015826522) (0.00011091943, -0.0015825861) (0.00011110982, -0.0015825384) (0.00011130397, -0.0015825096) (0.0001115, -0.0015825) (0.0001325, -0.0015825) (0.00013269603, -0.0015825096) (0.00013289018, -0.0015825384) (0.00013308057, -0.0015825861) (0.00013326537, -0.0015826522) (0.00013344279, -0.0015827362) (0.00013361114, -0.0015828371) (0.00013376879, -0.001582954) (0.00013391421, -0.0015830858) (0.00013404602, -0.0015832312) (0.00013416294, -0.0015833889) (0.00013426384, -0.0015835572) (0.00013434776, -0.0015837346) (0.00013441388, -0.0015839194) (0.00013446157, -0.0015841098) (0.00013449037, -0.001584304) (0.0001345, -0.0015845) (0.0001345, -0.0016455) (0.00013449037, -0.001645696) (0.00013446157, -0.0016458902) (0.00013441388, -0.0016460806) (0.00013434776, -0.0016462654) (0.00013426384, -0.0016464428) (0.00013416294, -0.0016466111) (0.00013404602, -0.0016467688) (0.00013391421, -0.0016469142) (0.00013376879, -0.001647046) (0.00013361114, -0.0016471629) (0.00013344279, -0.0016472638) (0.00013326537, -0.0016473478) (0.00013308057, -0.0016474139) (0.00013289018, -0.0016474616) (0.00013269603, -0.0016474904) (0.0001325, -0.0016475) (0.0001115, -0.0016475), closed, covered)
  pocket_cj_ch3 = polyline(z=0, xy: (5.15e-05, -0.0016635) (5.1303966e-05, -0.0016634904) (5.1109819e-05, -0.0016634616) (5.0919431e-05, -0.0016634139) (5.0734633e-05, -0.0016633478) (5.0557207e-05, -0.0016632638) (5.038886e-05, -0.0016631629) (5.0231213e-05, -0.001663046) (5.0085786e-05, -0.0016629142) (4.9953979e-05, -0.0016627688) (4.9837061e-05, -0.0016626111) (4.9736157e-05, -0.0016624428) (4.9652241e-05, -0.0016622654) (4.9586119e-05, -0.0016620806) (4.9538429e-05, -0.0016618902) (4.9509631e-05, -0.001661696) (4.95e-05, -0.0016615) (4.95e-05, -0.0015685) (4.9509631e-05, -0.001568304) (4.9538429e-05, -0.0015681098) (4.9586119e-05, -0.0015679194) (4.9652241e-05, -0.0015677346) (4.9736157e-05, -0.0015675572) (4.9837061e-05, -0.0015673889) (4.9953979e-05, -0.0015672312) (5.0085786e-05, -0.0015670858) (5.0231213e-05, -0.001566954) (5.038886e-05, -0.0015668371) (5.0557207e-05, -0.0015667362) (5.0734633e-05, -0.0015666522) (5.0919431e-05, -0.0015665861) (5.1109819e-05, -0.0015665384) (5.1303966e-05, -0.0015665096) (5.15e-05, -0.0015665) (0.0001485, -0.0015665) (0.00014869603, -0.0015665096) (0.00014889018, -0.0015665384) (0.00014908057, -0.0015665861) (0.00014926537, -0.0015666522) (0.00014944279, -0.0015667362) (0.00014961114, -0.0015668371) (0.00014976879, -0.001566954) (0.00014991421, -0.0015670858) (0.00015004602, -0.0015672312) (0.00015016294, -0.0015673889) (0.00015026384, -0.0015675572) (0.00015034776, -0.0015677346) (0.00015041388, -0.0015679194) (0.00015046157, -0.0015681098) (0.00015049037, -0.001568304) (0.0001505, -0.0015685) (0.0001505, -0.0016615) (0.00015049037, -0.001661696) (0.00015046157, -0.0016618902) (0.00015041388, -0.0016620806) (0.00015034776, -0.0016622654) (0.00015026384, -0.0016624428) (0.00015016294, -0.0016626111) (0.00015004602, -0.0016627688) (0.00014991421, -0.0016629142) (0.00014976879, -0.001663046) (0.00014961114, -0.0016631629) (0.00014944279, -0.0016632638) (0.00014926537, -0.0016633478) (0.00014908057, -0.0016634139) (0.00014889018, -0.0016634616) (0.00014869603, -0.0016634904) (0.0001485, -0.0016635) (5.15e-05, -0.0016635), closed, covered)
  endcap_res_a_ch3_start = rectangle(corner=(0.000189, -0.002921, 0), x_size=2.2e-05, y_size=6e-06)
  endcap_feed_in_start = rectangle(corner=(-0.001176, -1.1e-05, 0), x_size=6e-06, y_size=2.2e-05)
  endcap_feed_out_end = rectangle(corner=(0.00117, -1.1e-05, 0), x_size=6e-06, y_size=2.2e-05)
  ground_main_plane = rectangle(corner=(-0.00137, -0.003115, 0), x_size=0.00274, y_size=0.003326)
  main [silicon] = box(corner=(-0.00137, -0.003115, -0.000525), size=(0.00274, 0.003326, 0.000525))
  sample_holder [vacuum] = box(corner=(-0.00137, -0.003115, -0.00165), size=(0.00274, 0.003326, 0.00254))
  ground_main_plane.subtract(cut_stub_r_ch3, cut_res_ch3, lead_a_sub_cj_ch3, lead_a_sub_cp_ch3, pocket_cp_ch3, tap_cut_jr_ch3, cut_feed_out, pocket_cj_ch3, cut_stub_p_ch3, endcap_feed_out_end, tap_cut_jf_ch3, cut_filt_ch3, cut_feed_in, lead_b_sub_cj_ch3, endcap_feed_in_start, lead_b_sub_cp_ch3, cut_feed_jf_ch3, cut_res_a_ch3, tap_cut_n0_ch3, cut_stub_f_ch3, endcap_res_a_ch3_start)
  Port_feed_in_start = rectangle(corner=(-0.001176, -5e-06, 0), x_size=6e-06, y_size=1e-05)
  voltage_line_Port_feed_in_start = polyline((-0.00117, 0, 0) (-0.001176, 0, 0))
  Port_feed_out_end = rectangle(corner=(0.00117, -5e-06, 0), x_size=6e-06, y_size=1e-05)
  voltage_line_Port_feed_out_end = polyline((0.00117, 0, 0) (0.001176, 0, 0))
boundaries and excitations:
  PerfE: Perfect E Objects=[lead_a_cp_ch3, lead_b_cp_ch3, trace_stub_p_ch3, trace_feed_jf_ch3, lead_a_cj_ch3, lead_b_cj_ch3, trace_stub_f_ch3, trace_stub_r_ch3, trace_res_a_ch3, trace_filt_ch3, trace_res_ch3, trace_feed_in, trace_feed_out, tap_trace_n0_ch3, plate_cp_ch3, frame_cp_ch3, tap_trace_jf_ch3, tap_trace_jr_ch3, head_a_cj_ch3, head_b_cj_ch3, ground_main_plane]
  LumpPort_feed_in_start: Lumped Port Objects=Port_feed_in_start Modes{Mode1{IntLine{middle of Port_feed_in_start.edge(x at corner) -> middle of Port_feed_in_start.edge(x opposite corner)} CharImp=Zpi RenormImp=50ohm}} Impedance=50ohm
  LumpPort_feed_out_end: Lumped Port Objects=Port_feed_out_end Modes{Mode1{IntLine{middle of Port_feed_out_end.edge(x at corner) -> middle of Port_feed_out_end.edge(x opposite corner)} CharImp=Zpi RenormImp=50ohm}} Impedance=50ohm
setups:
  Setup: HfssDriven Frequency=6.71GHz MaxDeltaS=0.003 MaximumPasses=1 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=10 BasisOrder=2 PortAccuracy=2
    sweep Sweep: 6.5GHz to 6.95GHz, 1801 points; Type=Fast
source amplitudes:
  LumpPort_feed_in_start:1: 1W 0deg
  LumpPort_feed_out_end:1: 0W 0deg

design v6_full_eig_1611_hfss (HFSS, Eigenmode, model units mm)
geometry:
  lead_a_cp_ch3_path = polyline((0, -0.000362999, 0) (0, -0.000415, 0))
  lead_a_cp_ch3 = polyline((5e-06, -0.000362999, 0) (-5e-06, -0.000362999, 0))
  lead_a_cp_ch3.sweep_along_path(lead_a_cp_ch3_path)
  lead_a_sub_cp_ch3_path = polyline((0, -0.000362999, 0) (0, -0.000415, 0))
  lead_a_sub_cp_ch3 = polyline((1.1e-05, -0.000362999, 0) (-1.1e-05, -0.000362999, 0))
  lead_a_sub_cp_ch3.sweep_along_path(lead_a_sub_cp_ch3_path)
  lead_b_cp_ch3_path = polyline((0, -0.000262001, 0) (0, -0.00015, 0))
  lead_b_cp_ch3 = polyline((-5e-06, -0.000262001, 0) (5e-06, -0.000262001, 0))
  lead_b_cp_ch3.sweep_along_path(lead_b_cp_ch3_path)
  lead_b_sub_cp_ch3_path = polyline((0, -0.000262001, 0) (0, -0.00015, 0))
  lead_b_sub_cp_ch3 = polyline((-1.1e-05, -0.000262001, 0) (1.1e-05, -0.000262001, 0))
  lead_b_sub_cp_ch3.sweep_along_path(lead_b_sub_cp_ch3_path)
  trace_stub_p_ch3_path = polyline((0, -0.0001, 0) (0, -0.00015, 0))
  trace_stub_p_ch3 = polyline((5e-06, -0.0001, 0) (-5e-06, -0.0001, 0))
  trace_stub_p_ch3.sweep_along_path(trace_stub_p_ch3_path)
  cut_stub_p_ch3_path = polyline((0, -0.0001, 0) (0, -0.00015, 0))
  cut_stub_p_ch3 = polyline((1.1e-05, -0.0001, 0) (-1.1e-05, -0.0001, 0))
  cut_stub_p_ch3.sweep_along_path(cut_stub_p_ch3_path)
  trace_feed_jf_ch3_path = polyline((0, -0.000415, 0) (0, -0.001465, 0))
  trace_feed_jf_ch3 = polyline((5e-06, -0.000415, 0) (-5e-06, -0.000415, 0))
  trace_feed_jf_ch3.sweep_along_path(trace_feed_jf_ch3_path)
  cut_feed_jf_ch3_path = polyline((0, -0.000415, 0) (0, -0.001465, 0))
  cut_feed_jf_ch3 = polyline((1.1e-05, -0.000415, 0) (-1.1e-05, -0.000415, 0))
  cut_feed_jf_ch3.sweep_along_path(cut_feed_jf_ch3_path)
  lead_a_cj_ch3_path = polyline((6.5501e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  lead_a_cj_ch3 = polyline((6.5501e-05, -0.00162, 0) (6.5501e-05, -0.00161, 0))
  lead_a_cj_ch3.sweep_along_path(lead_a_cj_ch3_path)
  lead_a_sub_cj_ch3_path = polyline((6.5501e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  lead_a_sub_cj_ch3 = polyline((6.5501e-05, -0.001626, 0) (6.5501e-05, -0.001604, 0))
  lead_a_sub_cj_ch3.sweep_along_path(lead_a_sub_cj_ch3_path)
  lead_b_cj_ch3_path = polyline((0.000134499, -0.001615, 0) (0.0001445, -0.001615, 0))
  lead_b_cj_ch3 = polyline((0.000134499, -0.00161, 0) (0.000134499, -0.00162, 0))
  lead_b_cj_ch3.sweep_along_path(lead_b_cj_ch3_path)
  lead_b_sub_cj_ch3_path = polyline((0.000134499, -0.001615, 0) (0.0001445, -0.001615, 0))
  lead_b_sub_cj_ch3 = polyline((0.000134499, -0.001604, 0) (0.000134499, -0.001626, 0))
  lead_b_sub_cj_ch3.sweep_along_path(lead_b_sub_cj_ch3_path)
  trace_stub_f_ch3_path = polyline((3.55e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  trace_stub_f_ch3 = polyline((3.55e-05, -0.00161, 0) (3.55e-05, -0.00162, 0))
  trace_stub_f_ch3.sweep_along_path(trace_stub_f_ch3_path)
  cut_stub_f_ch3_path = polyline((3.55e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  cut_stub_f_ch3 = polyline((3.55e-05, -0.001604, 0) (3.55e-05, -0.001626, 0))
  cut_stub_f_ch3.sweep_along_path(cut_stub_f_ch3_path)
  trace_stub_r_ch3_path = polyline((0.0001645, -0.001615, 0) (0.0001445, -0.001615, 0))
  trace_stub_r_ch3 = polyline((0.0001645, -0.00162, 0) (0.0001645, -0.00161, 0))
  trace_stub_r_ch3.sweep_along_path(trace_stub_r_ch3_path)
  cut_stub_r_ch3_path = polyline((0.0001645, -0.001615, 0) (0.0001445, -0.001615, 0))
  cut_stub_r_ch3 = polyline((0.0001645, -0.001626, 0) (0.0001645, -0.001604, 0))
  cut_stub_r_ch3.sweep_along_path(cut_stub_r_ch3_path)
  trace_res_a_ch3_path = polyline((0.0002, -0.002915, 0) (0.0002, -0.001765, 0))
  trace_res_a_ch3 = polyline((0.000195, -0.002915, 0) (0.000205, -0.002915, 0))
  trace_res_a_ch3.sweep_along_path(trace_res_a_ch3_path)
  cut_res_a_ch3_path = polyline((0.0002, -0.002915, 0) (0.0002, -0.001765, 0))
  cut_res_a_ch3 = polyline((0.000189, -0.002915, 0) (0.000211, -0.002915, 0))
  cut_res_a_ch3.sweep_along_path(cut_res_a_ch3_path)
  trace_filt_ch3_path = polyline(z=0, xy: (-0.0003, -0.000915) (-0.0003, -0.0022822498) (0, -0.0022822498) (0, -0.001765))
  trace_filt_ch3_path.fillet(Vertices=trace_filt_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  trace_filt_ch3 = polyline((-0.000295, -0.000915, 0) (-0.000305, -0.000915, 0))
  trace_filt_ch3.sweep_along_path(trace_filt_ch3_path)
  cut_filt_ch3_path = polyline(z=0, xy: (-0.0003, -0.000915) (-0.0003, -0.0022822498) (0, -0.0022822498) (0, -0.001765))
  cut_filt_ch3_path.fillet(Vertices=cut_filt_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  cut_filt_ch3 = polyline((-0.000289, -0.000915, 0) (-0.000311, -0.000915, 0))
  cut_filt_ch3.sweep_along_path(cut_filt_ch3_path)
  trace_res_ch3_path = polyline(z=0, xy: (0.00055, -0.00255234) (0.00055, -0.000665) (0.0002, -0.000665) (0.0002, -0.001465))
  trace_res_ch3_path.fillet(Vertices=trace_res_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  trace_res_ch3 = polyline((0.000545, -0.00255234, 0) (0.000555, -0.00255234, 0))
  trace_res_ch3.sweep_along_path(trace_res_ch3_path)
  cut_res_ch3_path = polyline(z=0, xy: (0.00055, -0.00255234) (0.00055, -0.000665) (0.0002, -0.000665) (0.0002, -0.001465))
  cut_res_ch3_path.fillet(Vertices=cut_res_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  cut_res_ch3 = polyline((0.000539, -0.00255234, 0) (0.000561, -0.00255234, 0))
  cut_res_ch3.sweep_along_path(cut_res_ch3_path)
  trace_feed_in_path = polyline((-0.00117, 0, 0) (-0.00015, 0, 0))
  trace_feed_in = polyline((-0.00117, 5e-06, 0) (-0.00117, -5e-06, 0))
  trace_feed_in.sweep_along_path(trace_feed_in_path)
  cut_feed_in_path = polyline((-0.00117, 0, 0) (-0.00015, 0, 0))
  cut_feed_in = polyline((-0.00117, 1.1e-05, 0) (-0.00117, -1.1e-05, 0))
  cut_feed_in.sweep_along_path(cut_feed_in_path)
  trace_feed_out_path = polyline((0.00015, 0, 0) (0.00117, 0, 0))
  trace_feed_out = polyline((0.00015, 5e-06, 0) (0.00015, -5e-06, 0))
  trace_feed_out.sweep_along_path(trace_feed_out_path)
  cut_feed_out_path = polyline((0.00015, 0, 0) (0.00117, 0, 0))
  cut_feed_out = polyline((0.00015, 1.1e-05, 0) (0.00015, -1.1e-05, 0))
  cut_feed_out.sweep_along_path(cut_feed_out_path)
  g_wb [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-5.5e-05 YPadPos=-0.000765 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_1 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-5.5e-05 YPadPos=-0.001115 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_2 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000255 YPadPos=-0.0025316667 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_3 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000255 YPadPos=-0.0021483333 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_4 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0012568124 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_5 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0015986249 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_6 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0019404373 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_7 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=5.5e-05 YPadPos=-0.0020236249 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_8 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.002174872 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_9 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001797404 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_10 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001419936 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_11 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001042468 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_12 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000145 YPadPos=-0.00093166667 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_13 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000145 YPadPos=-0.0011983333 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_14 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00083 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_15 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00049 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_16 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00049 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_17 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00083 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  tap_trace_n0_ch3 = polyline(z=0, xy: (-5e-06, -0.0001) (-5e-06, -5e-06) (-0.00015, -5e-06) (-0.00015, 5e-06) (0.00015, 5e-06) (0.00015, -5e-06) (5e-06, -5e-06) (5e-06, -0.0001) (-5e-06, -0.0001), closed, covered)
  tap_cut_n0_ch3 = polyline(z=0, xy: (-1.1e-05, -0.0001) (-1.1e-05, -1.1e-05) (-0.00015, -1.1e-05) (-0.00015, 1.1e-05) (0.00015, 1.1e-05) (0.00015, -1.1e-05) (1.1e-05, -1.1e-05) (1.1e-05, -0.0001) (-1.1e-05, -0.0001), closed, covered)
  plate_cp_ch3 = polyline(z=0, xy: (8.25e-05, -0.000295) (8.2461478e-05, -0.00029578414) (8.2346282e-05, -0.00029656072) (8.2155523e-05, -0.00029732228) (8.1891036e-05, -0.00029806147) (8.155537e-05, -0.00029877117) (8.1151757e-05, -0.00029944456) (8.0684084e-05, -0.00030007515) (8.0156854e-05, -0.00030065685) (7.9575146e-05, -0.00030118408) (7.8944562e-05, -0.00030165176) (7.8271174e-05, -0.00030205537) (7.7561467e-05, -0.00030239104) (7.6822277e-05, -0.00030265552) (7.6060723e-05, -0.00030284628) (7.5284137e-05, -0.00030296148) (7.45e-05, -0.000303) (-7.45e-05, -0.000303) (-7.5284137e-05, -0.00030296148) (-7.6060723e-05, -0.00030284628) (-7.6822277e-05, -0.00030265552) (-7.7561467e-05, -0.00030239104) (-7.8271174e-05, -0.00030205537) (-7.8944562e-05, -0.00030165176) (-7.9575146e-05, -0.00030118408) (-8.0156854e-05, -0.00030065685) (-8.0684084e-05, -0.00030007515) (-8.1151757e-05, -0.00029944456) (-8.155537e-05, -0.00029877117) (-8.1891036e-05, -0.00029806147) (-8.2155523e-05, -0.00029732228) (-8.2346282e-05, -0.00029656072) (-8.2461478e-05, -0.00029578414) (-8.25e-05, -0.000295) (-8.25e-05, -0.00027) (-8.2461478e-05, -0.00026921586) (-8.2346282e-05, -0.00026843928) (-8.2155523e-05, -0.00026767772) (-8.1891036e-05, -0.00026693853) (-8.155537e-05, -0.00026622883) (-8.1151757e-05, -0.00026555544) (-8.0684084e-05, -0.00026492485) (-8.0156854e-05, -0.00026434315) (-7.9575146e-05, -0.00026381592) (-7.8944562e-05, -0.00026334824) (-7.8271174e-05, -0.00026294463) (-7.7561467e-05, -0.00026260896) (-7.6822277e-05, -0.00026234448) (-7.6060723e-05, -0.00026215372) (-7.5284137e-05, -0.00026203852) (-7.45e-05, -0.000262) (7.45e-05, -0.000262) (7.5284137e-05, -0.00026203852) (7.6060723e-05, -0.00026215372) (7.6822277e-05, -0.00026234448) (7.7561467e-05, -0.00026260896) (7.8271174e-05, -0.00026294463) (7.8944562e-05, -0.00026334824) (7.9575146e-05, -0.00026381592) (8.0156854e-05, -0.00026434315) (8.0684084e-05, -0.00026492485) (8.1151757e-05, -0.00026555544) (8.155537e-05, -0.00026622883) (8.1891036e-05, -0.00026693853) (8.2155523e-05, -0.00026767772) (8.2346282e-05, -0.00026843928) (8.2461478e-05, -0.00026921586) (8.25e-05, -0.00027) (8.25e-05, -0.000295), closed, covered)
  frame_cp_ch3 = polyline(z=0, xy: (8.25e-05, -0.000311) (8.3284137e-05, -0.00031096148) (8.4060723e-05, -0.00031084628) (8.4822277e-05, -0.00031065552) (8.5561467e-05, -0.00031039104) (8.6271174e-05, -0.00031005537) (8.6944562e-05, -0.00030965176) (8.7575146e-05, -0.00030918408) (8.8156854e-05, -0.00030865685) (8.8684084e-05, -0.00030807515) (8.9151757e-05, -0.00030744456) (8.955537e-05, -0.00030677117) (8.9891036e-05, -0.00030606147) (9.0155523e-05, -0.00030532228) (9.0346282e-05, -0.00030456072) (9.0461478e-05, -0.00030378414) (9.05e-05, -0.000303) (9.05e-05, -0.000262) (9.0461478e-05, -0.00026121586) (9.0346282e-05, -0.00026043928) (9.0155523e-05, -0.00025967772) (8.9891036e-05, -0.00025893853) (8.955537e-05, -0.00025822883) (8.9151757e-05, -0.00025755544) (8.8684084e-05, -0.00025692485) (8.8156854e-05, -0.00025634315) (8.7575146e-05, -0.00025581592) (8.6944562e-05, -0.00025534824) (8.6271174e-05, -0.00025494463) (8.5561467e-05, -0.00025460896) (8.4822277e-05, -0.00025434448) (8.4060723e-05, -0.00025415372) (8.3284137e-05, -0.00025403852) (8.25e-05, -0.000254) (1.909818e-05, -0.000254) (1.8901939e-05, -0.00025399518) (1.8412015e-05, -0.00025397111) (1.80216e-05, -0.00025393266) (1.7633541e-05, -0.0002538751) (1.7248774e-05, -0.00025379856) (1.6868226e-05, -0.00025370324) (1.6492814e-05, -0.00025358936) (1.6123441e-05, -0.0002534572) (1.5760999e-05, -0.00025330707) (1.540636e-05, -0.00025313934) (1.5060378e-05, -0.00025295441) (1.4723887e-05, -0.00025275272) (1.4397697e-05, -0.00025253477) (1.4082595e-05, -0.00025230107) (1.3779339e-05, -0.0002520522) (1.348866e-05, -0.00025178874) (1.3211259e-05, -0.00025151134) (1.2947803e-05, -0.00025122066) (1.2698928e-05, -0.0002509174) (1.2465232e-05, -0.0002506023) (1.2247279e-05, -0.00025027611) (1.2045594e-05, -0.00024993962) (1.1860663e-05, -0.00024959364) (1.1692931e-05, -0.000249239) (1.1542802e-05, -0.00024887656) (1.1410639e-05, -0.00024850719) (1.1296759e-05, -0.00024813177) (1.1201436e-05, -0.00024775123) (1.1124902e-05, -0.00024736646) (1.1067338e-05, -0.0002469784) (1.1028886e-05, -0.00024658799) (1.1004817e-05, -0.00024609806) (1.1e-05, -0.00024590182) (1.1e-05, -0.00019809818) (1.1004817e-05, -0.00019790194) (1.1028886e-05, -0.00019741201) (1.1067338e-05, -0.0001970216) (1.1124902e-05, -0.00019663354) (1.1201436e-05, -0.00019624877) (1.1296759e-05, -0.00019586823) (1.1410639e-05, -0.00019549281) (1.1542802e-05, -0.00019512344) (1.1692931e-05, -0.000194761) (1.1860663e-05, -0.00019440636) (1.2045594e-05, -0.00019406038) (1.2247279e-05, -0.00019372389) (1.2465232e-05, -0.0001933977) (1.2698928e-05, -0.00019308259) (1.2947803e-05, -0.00019277934) (1.3211259e-05, -0.00019248866) (1.348866e-05, -0.00019221126) (1.3779339e-05, -0.0001919478) (1.4082595e-05, -0.00019169893) (1.4397697e-05, -0.00019146523) (1.4723887e-05, -0.00019124728) (1.5060378e-05, -0.00019104559) (1.540636e-05, -0.00019086066) (1.5760999e-05, -0.00019069293) (1.6123441e-05, -0.0001905428) (1.6492814e-05, -0.00019041064) (1.6868226e-05, -0.00019029676) (1.7248774e-05, -0.00019020144) (1.7633541e-05, -0.0001901249) (1.80216e-05, -0.00019006734) (1.8412015e-05, -0.00019002889) (1.8901939e-05, -0.00019000482) (1.909818e-05, -0.00019) (0.00013940182, -0.00019) (0.00013959806, -0.00019000482) (0.00014008798, -0.00019002889) (0.0001404784, -0.00019006734) (0.00014086646, -0.0001901249) (0.00014125123, -0.00019020144) (0.00014163177, -0.00019029676) (0.00014200719, -0.00019041064) (0.00014237656, -0.0001905428) (0.000142739, -0.00019069293) (0.00014309364, -0.00019086066) (0.00014343962, -0.00019104559) (0.00014377611, -0.00019124728) (0.0001441023, -0.00019146523) (0.0001444174, -0.00019169893) (0.00014472066, -0.0001919478) (0.00014501134, -0.00019221126) (0.00014528874, -0.00019248866) (0.0001455522, -0.00019277934) (0.00014580107, -0.00019308259) (0.00014603477, -0.0001933977) (0.00014625272, -0.00019372389) (0.00014645441, -0.00019406038) (0.00014663934, -0.00019440636) (0.00014680707, -0.000194761) (0.0001469572, -0.00019512344) (0.00014708936, -0.00019549281) (0.00014720324, -0.00019586823) (0.00014729856, -0.00019624877) (0.0001473751, -0.00019663354) (0.00014743266, -0.0001970216) (0.00014747111, -0.00019741201) (0.00014749518, -0.00019790194) (0.0001475, -0.00019809818) (0.0001475, -0.00035490182) (0.00014749518, -0.00035509806) (0.00014747111, -0.00035558799) (0.00014743266, -0.0003559784) (0.0001473751, -0.00035636646) (0.00014729856, -0.00035675123) (0.00014720324, -0.00035713177) (0.00014708936, -0.00035750719) (0.0001469572, -0.00035787656) (0.00014680707, -0.000358239) (0.00014663934, -0.00035859364) (0.00014645441, -0.00035893962) (0.00014625272, -0.00035927611) (0.00014603477, -0.0003596023) (0.00014580107, -0.00035991741) (0.0001455522, -0.00036022066) (0.00014528874, -0.00036051134) (0.00014501134, -0.00036078874) (0.00014472066, -0.0003610522) (0.0001444174, -0.00036130107) (0.0001441023, -0.00036153477) (0.00014377611, -0.00036175272) (0.00014343962, -0.00036195441) (0.00014309364, -0.00036213934) (0.000142739, -0.00036230707) (0.00014237656, -0.0003624572) (0.00014200719, -0.00036258936) (0.00014163177, -0.00036270324) (0.00014125123, -0.00036279856) (0.00014086646, -0.0003628751) (0.0001404784, -0.00036293266) (0.00014008798, -0.00036297111) (0.00013959806, -0.00036299518) (0.00013940182, -0.000363) (-0.00013940182, -0.000363) (-0.00013959806, -0.00036299518) (-0.00014008798, -0.00036297111) (-0.0001404784, -0.00036293266) (-0.00014086646, -0.0003628751) (-0.00014125123, -0.00036279856) (-0.00014163177, -0.00036270324) (-0.00014200719, -0.00036258936) (-0.00014237656, -0.0003624572) (-0.000142739, -0.00036230707) (-0.00014309364, -0.00036213934) (-0.00014343962, -0.00036195441) (-0.00014377611, -0.00036175272) (-0.0001441023, -0.00036153477) (-0.0001444174, -0.00036130107) (-0.00014472066, -0.0003610522) (-0.00014501134, -0.00036078874) (-0.00014528874, -0.00036051134) (-0.0001455522, -0.00036022066) (-0.00014580107, -0.00035991741) (-0.00014603477, -0.0003596023) (-0.00014625272, -0.00035927611) (-0.00014645441, -0.00035893962) (-0.00014663934, -0.00035859364) (-0.00014680707, -0.000358239) (-0.0001469572, -0.00035787656) (-0.00014708936, -0.00035750719) (-0.00014720324, -0.00035713177) (-0.00014729856, -0.00035675123) (-0.0001473751, -0.00035636646) (-0.00014743266, -0.0003559784) (-0.00014747111, -0.00035558799) (-0.00014749518, -0.00035509806) (-0.0001475, -0.00035490182) (-0.0001475, -0.00019809818) (-0.00014749518, -0.00019790194) (-0.00014747111, -0.00019741201) (-0.00014743266, -0.0001970216) (-0.0001473751, -0.00019663354) (-0.00014729856, -0.00019624877) (-0.00014720324, -0.00019586823) (-0.00014708936, -0.00019549281) (-0.0001469572, -0.00019512344) (-0.00014680707, -0.000194761) (-0.00014663934, -0.00019440636) (-0.00014645441, -0.00019406038) (-0.00014625272, -0.00019372389) (-0.00014603477, -0.0001933977) (-0.00014580107, -0.00019308259) (-0.0001455522, -0.00019277934) (-0.00014528874, -0.00019248866) (-0.00014501134, -0.00019221126) (-0.00014472066, -0.0001919478) (-0.0001444174, -0.00019169893) (-0.0001441023, -0.00019146523) (-0.00014377611, -0.00019124728) (-0.00014343962, -0.00019104559) (-0.00014309364, -0.00019086066) (-0.000142739, -0.00019069293) (-0.00014237656, -0.0001905428) (-0.00014200719, -0.00019041064) (-0.00014163177, -0.00019029676) (-0.00014125123, -0.00019020144) (-0.00014086646, -0.0001901249) (-0.0001404784, -0.00019006734) (-0.00014008798, -0.00019002889) (-0.00013959806, -0.00019000482) (-0.00013940182, -0.00019) (-1.909818e-05, -0.00019) (-1.8901939e-05, -0.00019000482) (-1.8412015e-05, -0.00019002889) (-1.80216e-05, -0.00019006734) (-1.7633541e-05, -0.0001901249) (-1.7248774e-05, -0.00019020144) (-1.6868226e-05, -0.00019029676) (-1.6492814e-05, -0.00019041064) (-1.6123441e-05, -0.0001905428) (-1.5760999e-05, -0.00019069293) (-1.540636e-05, -0.00019086066) (-1.5060378e-05, -0.00019104559) (-1.4723887e-05, -0.00019124728) (-1.4397697e-05, -0.00019146523) (-1.4082595e-05, -0.00019169893) (-1.3779339e-05, -0.0001919478) (-1.348866e-05, -0.00019221126) (-1.3211259e-05, -0.00019248866) (-1.2947803e-05, -0.00019277934) (-1.2698928e-05, -0.00019308259) (-1.2465232e-05, -0.0001933977) (-1.2247279e-05, -0.00019372389) (-1.2045594e-05, -0.00019406038) (-1.1860663e-05, -0.00019440636) (-1.1692931e-05, -0.000194761) (-1.1542802e-05, -0.00019512344) (-1.1410639e-05, -0.00019549281) (-1.1296759e-05, -0.00019586823) (-1.1201436e-05, -0.00019624877) (-1.1124902e-05, -0.00019663354) (-1.1067338e-05, -0.0001970216) (-1.1028886e-05, -0.00019741201) (-1.1004817e-05, -0.00019790194) (-1.1e-05, -0.00019809818) (-1.1e-05, -0.00024590182) (-1.1004817e-05, -0.00024609806) (-1.1028886e-05, -0.00024658799) (-1.1067338e-05, -0.0002469784) (-1.1124902e-05, -0.00024736646) (-1.1201436e-05, -0.00024775123) (-1.1296759e-05, -0.00024813177) (-1.1410639e-05, -0.00024850719) (-1.1542802e-05, -0.00024887656) (-1.1692931e-05, -0.000249239) (-1.1860663e-05, -0.00024959364) (-1.2045594e-05, -0.00024993962) (-1.2247279e-05, -0.00025027611) (-1.2465232e-05, -0.0002506023) (-1.2698928e-05, -0.0002509174) (-1.2947803e-05, -0.00025122066) (-1.3211259e-05, -0.00025151134) (-1.348866e-05, -0.00025178874) (-1.3779339e-05, -0.0002520522) (-1.4082595e-05, -0.00025230107) (-1.4397697e-05, -0.00025253477) (-1.4723887e-05, -0.00025275272) (-1.5060378e-05, -0.00025295441) (-1.540636e-05, -0.00025313934) (-1.5760999e-05, -0.00025330707) (-1.6123441e-05, -0.0002534572) (-1.6492814e-05, -0.00025358936) (-1.6868226e-05, -0.00025370324)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, closed, covered)
  pocket_cp_ch3 = polyline(z=0, xy: (0.0001475, -0.000375) (-0.0001475, -0.000375) (-0.00014867621, -0.00037494222) (-0.00014984108, -0.00037476942) (-0.00015098342, -0.00037448328) (-0.0001520922, -0.00037408655) (-0.00015315676, -0.00037358305) (-0.00015416684, -0.00037297763) (-0.00015511272, -0.00037227612) (-0.00015598528, -0.00037148528) (-0.00015677613, -0.00037061272) (-0.00015747764, -0.00036966684) (-0.00015808305, -0.00036865676) (-0.00015858655, -0.0003675922) (-0.00015898328, -0.00036648342) (-0.00015926942, -0.00036534108) (-0.00015944222, -0.00036417621) (-0.0001595, -0.000363) (-0.0001595, -0.00019) (-0.00015944222, -0.00018882379) (-0.00015926942, -0.00018765892) (-0.00015898328, -0.00018651658) (-0.00015858655, -0.0001854078) (-0.00015808305, -0.00018434324) (-0.00015747764, -0.00018333316) (-0.00015677613, -0.00018238728) (-0.00015598528, -0.00018151472) (-0.00015511272, -0.00018072388) (-0.00015416684, -0.00018002237) (-0.00015315676, -0.00017941694) (-0.0001520922, -0.00017891345) (-0.00015098342, -0.00017851672) (-0.00014984108, -0.00017823058) (-0.00014867621, -0.00017805778) (-0.0001475, -0.000178) (0.0001475, -0.000178) (0.00014867621, -0.00017805778) (0.00014984108, -0.00017823058) (0.00015098342, -0.00017851672) (0.0001520922, -0.00017891345) (0.00015315676, -0.00017941694) (0.00015416684, -0.00018002237) (0.00015511272, -0.00018072388) (0.00015598528, -0.00018151472) (0.00015677613, -0.00018238728) (0.00015747764, -0.00018333316) (0.00015808305, -0.00018434324) (0.00015858655, -0.0001854078) (0.00015898328, -0.00018651658) (0.00015926942, -0.00018765892) (0.00015944222, -0.00018882379) (0.0001595, -0.00019) (0.0001595, -0.000363) (0.00015944222, -0.00036417621) (0.00015926942, -0.00036534108) (0.00015898328, -0.00036648342) (0.00015858655, -0.0003675922) (0.00015808305, -0.00036865676) (0.00015747764, -0.00036966684) (0.00015677613, -0.00037061272) (0.00015598528, -0.00037148528) (0.00015511272, -0.00037227612) (0.00015416684, -0.00037297763) (0.00015315676, -0.00037358305) (0.0001520922, -0.00037408655) (0.00015098342, -0.00037448328) (0.00014984108, -0.00037476942) (0.00014867621, -0.00037494222) (0.0001475, -0.000375), closed, covered)
  tap_trace_jf_ch3 = polyline(z=0, xy: (5e-06, -0.001465) (5e-06, -0.00161) (3.55e-05, -0.00161) (3.55e-05, -0.00162) (5e-06, -0.00162) (5e-06, -0.001765) (-5e-06, -0.001765) (-5e-06, -0.001465) (5e-06, -0.001465), closed, covered)
  tap_cut_jf_ch3 = polyline(z=0, xy: (1.1e-05, -0.001465) (1.1e-05, -0.001604) (3.55e-05, -0.001604) (3.55e-05, -0.001626) (1.1e-05, -0.001626) (1.1e-05, -0.001765) (-1.1e-05, -0.001765) (-1.1e-05, -0.001465) (1.1e-05, -0.001465), closed, covered)
  tap_trace_jr_ch3 = polyline(z=0, xy: (0.0001645, -0.00161) (0.000195, -0.00161) (0.000195, -0.001465) (0.000205, -0.001465) (0.000205, -0.001765) (0.000195, -0.001765) (0.000195, -0.00162) (0.0001645, -0.00162) (0.0001645, -0.00161), closed, covered)
  tap_cut_jr_ch3 = polyline(z=0, xy: (0.0001645, -0.001604) (0.000189, -0.001604) (0.000189, -0.001465) (0.000211, -0.001465) (0.000211, -0.001765) (0.000189, -0.001765) (0.000189, -0.001626) (0.0001645, -0.001626) (0.0001645, -0.001604), closed, covered)
  head_a_cj_ch3 = polyline(z=0, xy: (6.75e-05, -0.0016475) (6.7303966e-05, -0.0016474904) (6.7109819e-05, -0.0016474616) (6.6919431e-05, -0.0016474139) (6.6734633e-05, -0.0016473478) (6.6557207e-05, -0.0016472638) (6.638886e-05, -0.0016471629) (6.6231213e-05, -0.001647046) (6.6085786e-05, -0.0016469142) (6.5953979e-05, -0.0016467688) (6.5837061e-05, -0.0016466111) (6.5736157e-05, -0.0016464428) (6.5652241e-05, -0.0016462654) (6.5586119e-05, -0.0016460806) (6.5538429e-05, -0.0016458902) (6.5509631e-05, -0.001645696) (6.55e-05, -0.0016455) (6.55e-05, -0.0015845) (6.5509631e-05, -0.001584304) (6.5538429e-05, -0.0015841098) (6.5586119e-05, -0.0015839194) (6.5652241e-05, -0.0015837346) (6.5736157e-05, -0.0015835572) (6.5837061e-05, -0.0015833889) (6.5953979e-05, -0.0015832312) (6.6085786e-05, -0.0015830858) (6.6231213e-05, -0.001582954) (6.638886e-05, -0.0015828371) (6.6557207e-05, -0.0015827362) (6.6734633e-05, -0.0015826522) (6.6919431e-05, -0.0015825861) (6.7109819e-05, -0.0015825384) (6.7303966e-05, -0.0015825096) (6.75e-05, -0.0015825) (8.85e-05, -0.0015825) (8.8696034e-05, -0.0015825096) (8.8890181e-05, -0.0015825384) (8.9080569e-05, -0.0015825861) (8.9265367e-05, -0.0015826522) (8.9442793e-05, -0.0015827362) (8.961114e-05, -0.0015828371) (8.9768787e-05, -0.001582954) (8.9914214e-05, -0.0015830858) (9.0046021e-05, -0.0015832312) (9.0162939e-05, -0.0015833889) (9.0263843e-05, -0.0015835572) (9.0347759e-05, -0.0015837346) (9.0413881e-05, -0.0015839194) (9.0461571e-05, -0.0015841098) (9.0490369e-05, -0.001584304) (9.05e-05, -0.0015845) (9.05e-05, -0.0016455) (9.0490369e-05, -0.001645696) (9.0461571e-05, -0.0016458902) (9.0413881e-05, -0.0016460806) (9.0347759e-05, -0.0016462654) (9.0263843e-05, -0.0016464428) (9.0162939e-05, -0.0016466111) (9.0046021e-05, -0.0016467688) (8.9914214e-05, -0.0016469142) (8.9768787e-05, -0.001647046) (8.961114e-05, -0.0016471629) (8.9442793e-05, -0.0016472638) (8.9265367e-05, -0.0016473478) (8.9080569e-05, -0.0016474139) (8.8890181e-05, -0.0016474616) (8.8696034e-05, -0.0016474904) (8.85e-05, -0.0016475) (6.75e-05, -0.0016475), closed, covered)
  head_b_cj_ch3 = polyline(z=0, xy: (0.0001115, -0.0016475) (0.00011130397, -0.0016474904) (0.00011110982, -0.0016474616) (0.00011091943, -0.0016474139) (0.00011073463, -0.0016473478) (0.00011055721, -0.0016472638) (0.00011038886, -0.0016471629) (0.00011023121, -0.001647046) (0.00011008579, -0.0016469142) (0.00010995398, -0.0016467688) (0.00010983706, -0.0016466111) (0.00010973616, -0.0016464428) (0.00010965224, -0.0016462654) (0.00010958612, -0.0016460806) (0.00010953843, -0.0016458902) (0.00010950963, -0.001645696) (0.0001095, -0.0016455) (0.0001095, -0.0015845) (0.00010950963, -0.001584304) (0.00010953843, -0.0015841098) (0.00010958612, -0.0015839194) (0.00010965224, -0.0015837346) (0.00010973616, -0.0015835572) (0.00010983706, -0.0015833889) (0.00010995398, -0.0015832312) (0.00011008579, -0.0015830858) (0.00011023121, -0.001582954) (0.00011038886, -0.0015828371) (0.00011055721, -0.0015827362) (0.00011073463, -0.0015826522) (0.00011091943, -0.0015825861) (0.00011110982, -0.0015825384) (0.00011130397, -0.0015825096) (0.0001115, -0.0015825) (0.0001325, -0.0015825) (0.00013269603, -0.0015825096) (0.00013289018, -0.0015825384) (0.00013308057, -0.0015825861) (0.00013326537, -0.0015826522) (0.00013344279, -0.0015827362) (0.00013361114, -0.0015828371) (0.00013376879, -0.001582954) (0.00013391421, -0.0015830858) (0.00013404602, -0.0015832312) (0.00013416294, -0.0015833889) (0.00013426384, -0.0015835572) (0.00013434776, -0.0015837346) (0.00013441388, -0.0015839194) (0.00013446157, -0.0015841098) (0.00013449037, -0.001584304) (0.0001345, -0.0015845) (0.0001345, -0.0016455) (0.00013449037, -0.001645696) (0.00013446157, -0.0016458902) (0.00013441388, -0.0016460806) (0.00013434776, -0.0016462654) (0.00013426384, -0.0016464428) (0.00013416294, -0.0016466111) (0.00013404602, -0.0016467688) (0.00013391421, -0.0016469142) (0.00013376879, -0.001647046) (0.00013361114, -0.0016471629) (0.00013344279, -0.0016472638) (0.00013326537, -0.0016473478) (0.00013308057, -0.0016474139) (0.00013289018, -0.0016474616) (0.00013269603, -0.0016474904) (0.0001325, -0.0016475) (0.0001115, -0.0016475), closed, covered)
  pocket_cj_ch3 = polyline(z=0, xy: (5.15e-05, -0.0016635) (5.1303966e-05, -0.0016634904) (5.1109819e-05, -0.0016634616) (5.0919431e-05, -0.0016634139) (5.0734633e-05, -0.0016633478) (5.0557207e-05, -0.0016632638) (5.038886e-05, -0.0016631629) (5.0231213e-05, -0.001663046) (5.0085786e-05, -0.0016629142) (4.9953979e-05, -0.0016627688) (4.9837061e-05, -0.0016626111) (4.9736157e-05, -0.0016624428) (4.9652241e-05, -0.0016622654) (4.9586119e-05, -0.0016620806) (4.9538429e-05, -0.0016618902) (4.9509631e-05, -0.001661696) (4.95e-05, -0.0016615) (4.95e-05, -0.0015685) (4.9509631e-05, -0.001568304) (4.9538429e-05, -0.0015681098) (4.9586119e-05, -0.0015679194) (4.9652241e-05, -0.0015677346) (4.9736157e-05, -0.0015675572) (4.9837061e-05, -0.0015673889) (4.9953979e-05, -0.0015672312) (5.0085786e-05, -0.0015670858) (5.0231213e-05, -0.001566954) (5.038886e-05, -0.0015668371) (5.0557207e-05, -0.0015667362) (5.0734633e-05, -0.0015666522) (5.0919431e-05, -0.0015665861) (5.1109819e-05, -0.0015665384) (5.1303966e-05, -0.0015665096) (5.15e-05, -0.0015665) (0.0001485, -0.0015665) (0.00014869603, -0.0015665096) (0.00014889018, -0.0015665384) (0.00014908057, -0.0015665861) (0.00014926537, -0.0015666522) (0.00014944279, -0.0015667362) (0.00014961114, -0.0015668371) (0.00014976879, -0.001566954) (0.00014991421, -0.0015670858) (0.00015004602, -0.0015672312) (0.00015016294, -0.0015673889) (0.00015026384, -0.0015675572) (0.00015034776, -0.0015677346) (0.00015041388, -0.0015679194) (0.00015046157, -0.0015681098) (0.00015049037, -0.001568304) (0.0001505, -0.0015685) (0.0001505, -0.0016615) (0.00015049037, -0.001661696) (0.00015046157, -0.0016618902) (0.00015041388, -0.0016620806) (0.00015034776, -0.0016622654) (0.00015026384, -0.0016624428) (0.00015016294, -0.0016626111) (0.00015004602, -0.0016627688) (0.00014991421, -0.0016629142) (0.00014976879, -0.001663046) (0.00014961114, -0.0016631629) (0.00014944279, -0.0016632638) (0.00014926537, -0.0016633478) (0.00014908057, -0.0016634139) (0.00014889018, -0.0016634616) (0.00014869603, -0.0016634904) (0.0001485, -0.0016635) (5.15e-05, -0.0016635), closed, covered)
  endcap_res_a_ch3_start = rectangle(corner=(0.000189, -0.002921, 0), x_size=2.2e-05, y_size=6e-06)
  endcap_feed_in_start = rectangle(corner=(-0.001176, -1.1e-05, 0), x_size=6e-06, y_size=2.2e-05)
  endcap_feed_out_end = rectangle(corner=(0.00117, -1.1e-05, 0), x_size=6e-06, y_size=2.2e-05)
  ground_main_plane = rectangle(corner=(-0.00137, -0.003115, 0), x_size=0.00274, y_size=0.003326)
  main [silicon] = box(corner=(-0.00137, -0.003115, -0.000525), size=(0.00274, 0.003326, 0.000525))
  sample_holder [vacuum] = box(corner=(-0.00137, -0.003115, -0.00165), size=(0.00274, 0.003326, 0.00254))
  ground_main_plane.subtract(tap_cut_n0_ch3, cut_stub_p_ch3, cut_res_a_ch3, lead_b_sub_cj_ch3, lead_a_sub_cj_ch3, lead_a_sub_cp_ch3, endcap_res_a_ch3_start, endcap_feed_out_end, cut_res_ch3, tap_cut_jr_ch3, cut_filt_ch3, cut_feed_out, cut_stub_f_ch3, pocket_cj_ch3, cut_feed_jf_ch3, endcap_feed_in_start, lead_b_sub_cp_ch3, tap_cut_jf_ch3, pocket_cp_ch3, cut_feed_in, cut_stub_r_ch3)
  Port_feed_in_start = rectangle(corner=(-0.001176, -5e-06, 0), x_size=6e-06, y_size=1e-05)
  voltage_line_Port_feed_in_start = polyline((-0.00117, 0, 0) (-0.001176, 0, 0))
  Port_feed_out_end = rectangle(corner=(0.00117, -5e-06, 0), x_size=6e-06, y_size=1e-05)
  voltage_line_Port_feed_out_end = polyline((0.00117, 0, 0) (0.001176, 0, 0))
boundaries and excitations:
  RLCBoundary_feed_in_start: Lumped RLC Objects=Port_feed_in_start CurrentLine{middle of Port_feed_in_start.edge(x at corner) -> middle of Port_feed_in_start.edge(x opposite corner)} RLC_Type=Parallel Resistance=50ohm
  RLCBoundary_feed_out_end: Lumped RLC Objects=Port_feed_out_end CurrentLine{middle of Port_feed_out_end.edge(x at corner) -> middle of Port_feed_out_end.edge(x opposite corner)} RLC_Type=Parallel Resistance=50ohm
  PerfE: Perfect E Objects=[lead_a_cp_ch3, lead_b_cp_ch3, trace_stub_p_ch3, trace_feed_jf_ch3, lead_a_cj_ch3, lead_b_cj_ch3, trace_stub_f_ch3, trace_stub_r_ch3, trace_res_a_ch3, trace_filt_ch3, trace_res_ch3, trace_feed_in, trace_feed_out, tap_trace_n0_ch3, plate_cp_ch3, frame_cp_ch3, tap_trace_jf_ch3, tap_trace_jr_ch3, head_a_cj_ch3, head_b_cj_ch3, ground_main_plane]
mesh:
  port_mesh: LengthBased Objects=[Port_feed_in_start, Port_feed_out_end] MaxLength=7um
  cpw_line_mesh: LengthBased Objects=[trace_stub_p_ch3, trace_feed_jf_ch3, trace_stub_f_ch3, trace_stub_r_ch3, trace_res_a_ch3, trace_filt_ch3, trace_res_ch3, trace_feed_in, trace_feed_out, tap_trace_n0_ch3, tap_trace_jf_ch3, tap_trace_jr_ch3] MaxLength=10um
  cap_mesh: LengthBased Objects=[lead_a_cp_ch3, lead_b_cp_ch3, lead_a_cj_ch3, lead_b_cj_ch3, plate_cp_ch3, frame_cp_ch3, head_a_cj_ch3, head_b_cj_ch3] MaxLength=5um
setups:
  Setup: HfssEigen MinimumFrequency=6.5GHz NumModes=2 MaxDeltaFreq=0.1 ConvergeOnRealFreq=true MaximumPasses=3 MinimumPasses=3 MinimumConvergedPasses=2 PercentRefinement=20 BasisOrder=1
source amplitudes:
  #-10:1: 1 0deg
  #-10:2: 0 0deg
field plots:
  Mesh1: MeshPlots in main on Setup : LastAdaptive at Phase=0deg
reports:
  Freq. vs. pass: re(Mode(1)), re(Mode(2)) vs Pass on Setup : AdaptivePass

design v6_full_1625_hfss (HFSS, DrivenModal, model units mm)
geometry:
  lead_a_cp_ch3_path = polyline((0, -0.000362999, 0) (0, -0.000415, 0))
  lead_a_cp_ch3 = polyline((5e-06, -0.000362999, 0) (-5e-06, -0.000362999, 0))
  lead_a_cp_ch3.sweep_along_path(lead_a_cp_ch3_path)
  lead_a_sub_cp_ch3_path = polyline((0, -0.000362999, 0) (0, -0.000415, 0))
  lead_a_sub_cp_ch3 = polyline((1.1e-05, -0.000362999, 0) (-1.1e-05, -0.000362999, 0))
  lead_a_sub_cp_ch3.sweep_along_path(lead_a_sub_cp_ch3_path)
  lead_b_cp_ch3_path = polyline((0, -0.000262001, 0) (0, -0.00015, 0))
  lead_b_cp_ch3 = polyline((-5e-06, -0.000262001, 0) (5e-06, -0.000262001, 0))
  lead_b_cp_ch3.sweep_along_path(lead_b_cp_ch3_path)
  lead_b_sub_cp_ch3_path = polyline((0, -0.000262001, 0) (0, -0.00015, 0))
  lead_b_sub_cp_ch3 = polyline((-1.1e-05, -0.000262001, 0) (1.1e-05, -0.000262001, 0))
  lead_b_sub_cp_ch3.sweep_along_path(lead_b_sub_cp_ch3_path)
  trace_stub_p_ch3_path = polyline((0, -0.0001, 0) (0, -0.00015, 0))
  trace_stub_p_ch3 = polyline((5e-06, -0.0001, 0) (-5e-06, -0.0001, 0))
  trace_stub_p_ch3.sweep_along_path(trace_stub_p_ch3_path)
  cut_stub_p_ch3_path = polyline((0, -0.0001, 0) (0, -0.00015, 0))
  cut_stub_p_ch3 = polyline((1.1e-05, -0.0001, 0) (-1.1e-05, -0.0001, 0))
  cut_stub_p_ch3.sweep_along_path(cut_stub_p_ch3_path)
  trace_feed_jf_ch3_path = polyline((0, -0.000415, 0) (0, -0.001465, 0))
  trace_feed_jf_ch3 = polyline((5e-06, -0.000415, 0) (-5e-06, -0.000415, 0))
  trace_feed_jf_ch3.sweep_along_path(trace_feed_jf_ch3_path)
  cut_feed_jf_ch3_path = polyline((0, -0.000415, 0) (0, -0.001465, 0))
  cut_feed_jf_ch3 = polyline((1.1e-05, -0.000415, 0) (-1.1e-05, -0.000415, 0))
  cut_feed_jf_ch3.sweep_along_path(cut_feed_jf_ch3_path)
  lead_a_cj_ch3_path = polyline((6.5501e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  lead_a_cj_ch3 = polyline((6.5501e-05, -0.00162, 0) (6.5501e-05, -0.00161, 0))
  lead_a_cj_ch3.sweep_along_path(lead_a_cj_ch3_path)
  lead_a_sub_cj_ch3_path = polyline((6.5501e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  lead_a_sub_cj_ch3 = polyline((6.5501e-05, -0.001626, 0) (6.5501e-05, -0.001604, 0))
  lead_a_sub_cj_ch3.sweep_along_path(lead_a_sub_cj_ch3_path)
  lead_b_cj_ch3_path = polyline((0.000134499, -0.001615, 0) (0.0001445, -0.001615, 0))
  lead_b_cj_ch3 = polyline((0.000134499, -0.00161, 0) (0.000134499, -0.00162, 0))
  lead_b_cj_ch3.sweep_along_path(lead_b_cj_ch3_path)
  lead_b_sub_cj_ch3_path = polyline((0.000134499, -0.001615, 0) (0.0001445, -0.001615, 0))
  lead_b_sub_cj_ch3 = polyline((0.000134499, -0.001604, 0) (0.000134499, -0.001626, 0))
  lead_b_sub_cj_ch3.sweep_along_path(lead_b_sub_cj_ch3_path)
  trace_stub_f_ch3_path = polyline((3.55e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  trace_stub_f_ch3 = polyline((3.55e-05, -0.00161, 0) (3.55e-05, -0.00162, 0))
  trace_stub_f_ch3.sweep_along_path(trace_stub_f_ch3_path)
  cut_stub_f_ch3_path = polyline((3.55e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  cut_stub_f_ch3 = polyline((3.55e-05, -0.001604, 0) (3.55e-05, -0.001626, 0))
  cut_stub_f_ch3.sweep_along_path(cut_stub_f_ch3_path)
  trace_stub_r_ch3_path = polyline((0.0001645, -0.001615, 0) (0.0001445, -0.001615, 0))
  trace_stub_r_ch3 = polyline((0.0001645, -0.00162, 0) (0.0001645, -0.00161, 0))
  trace_stub_r_ch3.sweep_along_path(trace_stub_r_ch3_path)
  cut_stub_r_ch3_path = polyline((0.0001645, -0.001615, 0) (0.0001445, -0.001615, 0))
  cut_stub_r_ch3 = polyline((0.0001645, -0.001626, 0) (0.0001645, -0.001604, 0))
  cut_stub_r_ch3.sweep_along_path(cut_stub_r_ch3_path)
  trace_res_a_ch3_path = polyline((0.0002, -0.002915, 0) (0.0002, -0.001765, 0))
  trace_res_a_ch3 = polyline((0.000195, -0.002915, 0) (0.000205, -0.002915, 0))
  trace_res_a_ch3.sweep_along_path(trace_res_a_ch3_path)
  cut_res_a_ch3_path = polyline((0.0002, -0.002915, 0) (0.0002, -0.001765, 0))
  cut_res_a_ch3 = polyline((0.000189, -0.002915, 0) (0.000211, -0.002915, 0))
  cut_res_a_ch3.sweep_along_path(cut_res_a_ch3_path)
  trace_filt_ch3_path = polyline(z=0, xy: (-0.0003, -0.000915) (-0.0003, -0.0022822498) (0, -0.0022822498) (0, -0.001765))
  trace_filt_ch3_path.fillet(Vertices=trace_filt_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  trace_filt_ch3 = polyline((-0.000295, -0.000915, 0) (-0.000305, -0.000915, 0))
  trace_filt_ch3.sweep_along_path(trace_filt_ch3_path)
  cut_filt_ch3_path = polyline(z=0, xy: (-0.0003, -0.000915) (-0.0003, -0.0022822498) (0, -0.0022822498) (0, -0.001765))
  cut_filt_ch3_path.fillet(Vertices=cut_filt_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  cut_filt_ch3 = polyline((-0.000289, -0.000915, 0) (-0.000311, -0.000915, 0))
  cut_filt_ch3.sweep_along_path(cut_filt_ch3_path)
  trace_res_ch3_path = polyline(z=0, xy: (0.00055, -0.00255234) (0.00055, -0.000665) (0.0002, -0.000665) (0.0002, -0.001465))
  trace_res_ch3_path.fillet(Vertices=trace_res_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  trace_res_ch3 = polyline((0.000545, -0.00255234, 0) (0.000555, -0.00255234, 0))
  trace_res_ch3.sweep_along_path(trace_res_ch3_path)
  cut_res_ch3_path = polyline(z=0, xy: (0.00055, -0.00255234) (0.00055, -0.000665) (0.0002, -0.000665) (0.0002, -0.001465))
  cut_res_ch3_path.fillet(Vertices=cut_res_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  cut_res_ch3 = polyline((0.000539, -0.00255234, 0) (0.000561, -0.00255234, 0))
  cut_res_ch3.sweep_along_path(cut_res_ch3_path)
  trace_feed_in_path = polyline((-0.00117, 0, 0) (-0.00015, 0, 0))
  trace_feed_in = polyline((-0.00117, 5e-06, 0) (-0.00117, -5e-06, 0))
  trace_feed_in.sweep_along_path(trace_feed_in_path)
  cut_feed_in_path = polyline((-0.00117, 0, 0) (-0.00015, 0, 0))
  cut_feed_in = polyline((-0.00117, 1.1e-05, 0) (-0.00117, -1.1e-05, 0))
  cut_feed_in.sweep_along_path(cut_feed_in_path)
  trace_feed_out_path = polyline((0.00015, 0, 0) (0.00117, 0, 0))
  trace_feed_out = polyline((0.00015, 5e-06, 0) (0.00015, -5e-06, 0))
  trace_feed_out.sweep_along_path(trace_feed_out_path)
  cut_feed_out_path = polyline((0.00015, 0, 0) (0.00117, 0, 0))
  cut_feed_out = polyline((0.00015, 1.1e-05, 0) (0.00015, -1.1e-05, 0))
  cut_feed_out.sweep_along_path(cut_feed_out_path)
  g_wb [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-5.5e-05 YPadPos=-0.000765 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_1 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-5.5e-05 YPadPos=-0.001115 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_2 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000255 YPadPos=-0.0025316667 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_3 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000255 YPadPos=-0.0021483333 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_4 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0012568124 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_5 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0015986249 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_6 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0019404373 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_7 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=5.5e-05 YPadPos=-0.0020236249 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_8 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.002174872 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_9 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001797404 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_10 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001419936 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_11 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001042468 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_12 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000145 YPadPos=-0.00093166667 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_13 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000145 YPadPos=-0.0011983333 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_14 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00083 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_15 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00049 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_16 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00049 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_17 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00083 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  tap_trace_n0_ch3 = polyline(z=0, xy: (-5e-06, -0.0001) (-5e-06, -5e-06) (-0.00015, -5e-06) (-0.00015, 5e-06) (0.00015, 5e-06) (0.00015, -5e-06) (5e-06, -5e-06) (5e-06, -0.0001) (-5e-06, -0.0001), closed, covered)
  tap_cut_n0_ch3 = polyline(z=0, xy: (-1.1e-05, -0.0001) (-1.1e-05, -1.1e-05) (-0.00015, -1.1e-05) (-0.00015, 1.1e-05) (0.00015, 1.1e-05) (0.00015, -1.1e-05) (1.1e-05, -1.1e-05) (1.1e-05, -0.0001) (-1.1e-05, -0.0001), closed, covered)
  plate_cp_ch3 = polyline(z=0, xy: (8.25e-05, -0.000295) (8.2461478e-05, -0.00029578414) (8.2346282e-05, -0.00029656072) (8.2155523e-05, -0.00029732228) (8.1891036e-05, -0.00029806147) (8.155537e-05, -0.00029877117) (8.1151757e-05, -0.00029944456) (8.0684084e-05, -0.00030007515) (8.0156854e-05, -0.00030065685) (7.9575146e-05, -0.00030118408) (7.8944562e-05, -0.00030165176) (7.8271174e-05, -0.00030205537) (7.7561467e-05, -0.00030239104) (7.6822277e-05, -0.00030265552) (7.6060723e-05, -0.00030284628) (7.5284137e-05, -0.00030296148) (7.45e-05, -0.000303) (-7.45e-05, -0.000303) (-7.5284137e-05, -0.00030296148) (-7.6060723e-05, -0.00030284628) (-7.6822277e-05, -0.00030265552) (-7.7561467e-05, -0.00030239104) (-7.8271174e-05, -0.00030205537) (-7.8944562e-05, -0.00030165176) (-7.9575146e-05, -0.00030118408) (-8.0156854e-05, -0.00030065685) (-8.0684084e-05, -0.00030007515) (-8.1151757e-05, -0.00029944456) (-8.155537e-05, -0.00029877117) (-8.1891036e-05, -0.00029806147) (-8.2155523e-05, -0.00029732228) (-8.2346282e-05, -0.00029656072) (-8.2461478e-05, -0.00029578414) (-8.25e-05, -0.000295) (-8.25e-05, -0.00027) (-8.2461478e-05, -0.00026921586) (-8.2346282e-05, -0.00026843928) (-8.2155523e-05, -0.00026767772) (-8.1891036e-05, -0.00026693853) (-8.155537e-05, -0.00026622883) (-8.1151757e-05, -0.00026555544) (-8.0684084e-05, -0.00026492485) (-8.0156854e-05, -0.00026434315) (-7.9575146e-05, -0.00026381592) (-7.8944562e-05, -0.00026334824) (-7.8271174e-05, -0.00026294463) (-7.7561467e-05, -0.00026260896) (-7.6822277e-05, -0.00026234448) (-7.6060723e-05, -0.00026215372) (-7.5284137e-05, -0.00026203852) (-7.45e-05, -0.000262) (7.45e-05, -0.000262) (7.5284137e-05, -0.00026203852) (7.6060723e-05, -0.00026215372) (7.6822277e-05, -0.00026234448) (7.7561467e-05, -0.00026260896) (7.8271174e-05, -0.00026294463) (7.8944562e-05, -0.00026334824) (7.9575146e-05, -0.00026381592) (8.0156854e-05, -0.00026434315) (8.0684084e-05, -0.00026492485) (8.1151757e-05, -0.00026555544) (8.155537e-05, -0.00026622883) (8.1891036e-05, -0.00026693853) (8.2155523e-05, -0.00026767772) (8.2346282e-05, -0.00026843928) (8.2461478e-05, -0.00026921586) (8.25e-05, -0.00027) (8.25e-05, -0.000295), closed, covered)
  frame_cp_ch3 = polyline(z=0, xy: (8.25e-05, -0.000311) (8.3284137e-05, -0.00031096148) (8.4060723e-05, -0.00031084628) (8.4822277e-05, -0.00031065552) (8.5561467e-05, -0.00031039104) (8.6271174e-05, -0.00031005537) (8.6944562e-05, -0.00030965176) (8.7575146e-05, -0.00030918408) (8.8156854e-05, -0.00030865685) (8.8684084e-05, -0.00030807515) (8.9151757e-05, -0.00030744456) (8.955537e-05, -0.00030677117) (8.9891036e-05, -0.00030606147) (9.0155523e-05, -0.00030532228) (9.0346282e-05, -0.00030456072) (9.0461478e-05, -0.00030378414) (9.05e-05, -0.000303) (9.05e-05, -0.000262) (9.0461478e-05, -0.00026121586) (9.0346282e-05, -0.00026043928) (9.0155523e-05, -0.00025967772) (8.9891036e-05, -0.00025893853) (8.955537e-05, -0.00025822883) (8.9151757e-05, -0.00025755544) (8.8684084e-05, -0.00025692485) (8.8156854e-05, -0.00025634315) (8.7575146e-05, -0.00025581592) (8.6944562e-05, -0.00025534824) (8.6271174e-05, -0.00025494463) (8.5561467e-05, -0.00025460896) (8.4822277e-05, -0.00025434448) (8.4060723e-05, -0.00025415372) (8.3284137e-05, -0.00025403852) (8.25e-05, -0.000254) (1.909818e-05, -0.000254) (1.8901939e-05, -0.00025399518) (1.8412015e-05, -0.00025397111) (1.80216e-05, -0.00025393266) (1.7633541e-05, -0.0002538751) (1.7248774e-05, -0.00025379856) (1.6868226e-05, -0.00025370324) (1.6492814e-05, -0.00025358936) (1.6123441e-05, -0.0002534572) (1.5760999e-05, -0.00025330707) (1.540636e-05, -0.00025313934) (1.5060378e-05, -0.00025295441) (1.4723887e-05, -0.00025275272) (1.4397697e-05, -0.00025253477) (1.4082595e-05, -0.00025230107) (1.3779339e-05, -0.0002520522) (1.348866e-05, -0.00025178874) (1.3211259e-05, -0.00025151134) (1.2947803e-05, -0.00025122066) (1.2698928e-05, -0.0002509174) (1.2465232e-05, -0.0002506023) (1.2247279e-05, -0.00025027611) (1.2045594e-05, -0.00024993962) (1.1860663e-05, -0.00024959364) (1.1692931e-05, -0.000249239) (1.1542802e-05, -0.00024887656) (1.1410639e-05, -0.00024850719) (1.1296759e-05, -0.00024813177) (1.1201436e-05, -0.00024775123) (1.1124902e-05, -0.00024736646) (1.1067338e-05, -0.0002469784) (1.1028886e-05, -0.00024658799) (1.1004817e-05, -0.00024609806) (1.1e-05, -0.00024590182) (1.1e-05, -0.00019809818) (1.1004817e-05, -0.00019790194) (1.1028886e-05, -0.00019741201) (1.1067338e-05, -0.0001970216) (1.1124902e-05, -0.00019663354) (1.1201436e-05, -0.00019624877) (1.1296759e-05, -0.00019586823) (1.1410639e-05, -0.00019549281) (1.1542802e-05, -0.00019512344) (1.1692931e-05, -0.000194761) (1.1860663e-05, -0.00019440636) (1.2045594e-05, -0.00019406038) (1.2247279e-05, -0.00019372389) (1.2465232e-05, -0.0001933977) (1.2698928e-05, -0.00019308259) (1.2947803e-05, -0.00019277934) (1.3211259e-05, -0.00019248866) (1.348866e-05, -0.00019221126) (1.3779339e-05, -0.0001919478) (1.4082595e-05, -0.00019169893) (1.4397697e-05, -0.00019146523) (1.4723887e-05, -0.00019124728) (1.5060378e-05, -0.00019104559) (1.540636e-05, -0.00019086066) (1.5760999e-05, -0.00019069293) (1.6123441e-05, -0.0001905428) (1.6492814e-05, -0.00019041064) (1.6868226e-05, -0.00019029676) (1.7248774e-05, -0.00019020144) (1.7633541e-05, -0.0001901249) (1.80216e-05, -0.00019006734) (1.8412015e-05, -0.00019002889) (1.8901939e-05, -0.00019000482) (1.909818e-05, -0.00019) (0.00013940182, -0.00019) (0.00013959806, -0.00019000482) (0.00014008798, -0.00019002889) (0.0001404784, -0.00019006734) (0.00014086646, -0.0001901249) (0.00014125123, -0.00019020144) (0.00014163177, -0.00019029676) (0.00014200719, -0.00019041064) (0.00014237656, -0.0001905428) (0.000142739, -0.00019069293) (0.00014309364, -0.00019086066) (0.00014343962, -0.00019104559) (0.00014377611, -0.00019124728) (0.0001441023, -0.00019146523) (0.0001444174, -0.00019169893) (0.00014472066, -0.0001919478) (0.00014501134, -0.00019221126) (0.00014528874, -0.00019248866) (0.0001455522, -0.00019277934) (0.00014580107, -0.00019308259) (0.00014603477, -0.0001933977) (0.00014625272, -0.00019372389) (0.00014645441, -0.00019406038) (0.00014663934, -0.00019440636) (0.00014680707, -0.000194761) (0.0001469572, -0.00019512344) (0.00014708936, -0.00019549281) (0.00014720324, -0.00019586823) (0.00014729856, -0.00019624877) (0.0001473751, -0.00019663354) (0.00014743266, -0.0001970216) (0.00014747111, -0.00019741201) (0.00014749518, -0.00019790194) (0.0001475, -0.00019809818) (0.0001475, -0.00035490182) (0.00014749518, -0.00035509806) (0.00014747111, -0.00035558799) (0.00014743266, -0.0003559784) (0.0001473751, -0.00035636646) (0.00014729856, -0.00035675123) (0.00014720324, -0.00035713177) (0.00014708936, -0.00035750719) (0.0001469572, -0.00035787656) (0.00014680707, -0.000358239) (0.00014663934, -0.00035859364) (0.00014645441, -0.00035893962) (0.00014625272, -0.00035927611) (0.00014603477, -0.0003596023) (0.00014580107, -0.00035991741) (0.0001455522, -0.00036022066) (0.00014528874, -0.00036051134) (0.00014501134, -0.00036078874) (0.00014472066, -0.0003610522) (0.0001444174, -0.00036130107) (0.0001441023, -0.00036153477) (0.00014377611, -0.00036175272) (0.00014343962, -0.00036195441) (0.00014309364, -0.00036213934) (0.000142739, -0.00036230707) (0.00014237656, -0.0003624572) (0.00014200719, -0.00036258936) (0.00014163177, -0.00036270324) (0.00014125123, -0.00036279856) (0.00014086646, -0.0003628751) (0.0001404784, -0.00036293266) (0.00014008798, -0.00036297111) (0.00013959806, -0.00036299518) (0.00013940182, -0.000363) (-0.00013940182, -0.000363) (-0.00013959806, -0.00036299518) (-0.00014008798, -0.00036297111) (-0.0001404784, -0.00036293266) (-0.00014086646, -0.0003628751) (-0.00014125123, -0.00036279856) (-0.00014163177, -0.00036270324) (-0.00014200719, -0.00036258936) (-0.00014237656, -0.0003624572) (-0.000142739, -0.00036230707) (-0.00014309364, -0.00036213934) (-0.00014343962, -0.00036195441) (-0.00014377611, -0.00036175272) (-0.0001441023, -0.00036153477) (-0.0001444174, -0.00036130107) (-0.00014472066, -0.0003610522) (-0.00014501134, -0.00036078874) (-0.00014528874, -0.00036051134) (-0.0001455522, -0.00036022066) (-0.00014580107, -0.00035991741) (-0.00014603477, -0.0003596023) (-0.00014625272, -0.00035927611) (-0.00014645441, -0.00035893962) (-0.00014663934, -0.00035859364) (-0.00014680707, -0.000358239) (-0.0001469572, -0.00035787656) (-0.00014708936, -0.00035750719) (-0.00014720324, -0.00035713177) (-0.00014729856, -0.00035675123) (-0.0001473751, -0.00035636646) (-0.00014743266, -0.0003559784) (-0.00014747111, -0.00035558799) (-0.00014749518, -0.00035509806) (-0.0001475, -0.00035490182) (-0.0001475, -0.00019809818) (-0.00014749518, -0.00019790194) (-0.00014747111, -0.00019741201) (-0.00014743266, -0.0001970216) (-0.0001473751, -0.00019663354) (-0.00014729856, -0.00019624877) (-0.00014720324, -0.00019586823) (-0.00014708936, -0.00019549281) (-0.0001469572, -0.00019512344) (-0.00014680707, -0.000194761) (-0.00014663934, -0.00019440636) (-0.00014645441, -0.00019406038) (-0.00014625272, -0.00019372389) (-0.00014603477, -0.0001933977) (-0.00014580107, -0.00019308259) (-0.0001455522, -0.00019277934) (-0.00014528874, -0.00019248866) (-0.00014501134, -0.00019221126) (-0.00014472066, -0.0001919478) (-0.0001444174, -0.00019169893) (-0.0001441023, -0.00019146523) (-0.00014377611, -0.00019124728) (-0.00014343962, -0.00019104559) (-0.00014309364, -0.00019086066) (-0.000142739, -0.00019069293) (-0.00014237656, -0.0001905428) (-0.00014200719, -0.00019041064) (-0.00014163177, -0.00019029676) (-0.00014125123, -0.00019020144) (-0.00014086646, -0.0001901249) (-0.0001404784, -0.00019006734) (-0.00014008798, -0.00019002889) (-0.00013959806, -0.00019000482) (-0.00013940182, -0.00019) (-1.909818e-05, -0.00019) (-1.8901939e-05, -0.00019000482) (-1.8412015e-05, -0.00019002889) (-1.80216e-05, -0.00019006734) (-1.7633541e-05, -0.0001901249) (-1.7248774e-05, -0.00019020144) (-1.6868226e-05, -0.00019029676) (-1.6492814e-05, -0.00019041064) (-1.6123441e-05, -0.0001905428) (-1.5760999e-05, -0.00019069293) (-1.540636e-05, -0.00019086066) (-1.5060378e-05, -0.00019104559) (-1.4723887e-05, -0.00019124728) (-1.4397697e-05, -0.00019146523) (-1.4082595e-05, -0.00019169893) (-1.3779339e-05, -0.0001919478) (-1.348866e-05, -0.00019221126) (-1.3211259e-05, -0.00019248866) (-1.2947803e-05, -0.00019277934) (-1.2698928e-05, -0.00019308259) (-1.2465232e-05, -0.0001933977) (-1.2247279e-05, -0.00019372389) (-1.2045594e-05, -0.00019406038) (-1.1860663e-05, -0.00019440636) (-1.1692931e-05, -0.000194761) (-1.1542802e-05, -0.00019512344) (-1.1410639e-05, -0.00019549281) (-1.1296759e-05, -0.00019586823) (-1.1201436e-05, -0.00019624877) (-1.1124902e-05, -0.00019663354) (-1.1067338e-05, -0.0001970216) (-1.1028886e-05, -0.00019741201) (-1.1004817e-05, -0.00019790194) (-1.1e-05, -0.00019809818) (-1.1e-05, -0.00024590182) (-1.1004817e-05, -0.00024609806) (-1.1028886e-05, -0.00024658799) (-1.1067338e-05, -0.0002469784) (-1.1124902e-05, -0.00024736646) (-1.1201436e-05, -0.00024775123) (-1.1296759e-05, -0.00024813177) (-1.1410639e-05, -0.00024850719) (-1.1542802e-05, -0.00024887656) (-1.1692931e-05, -0.000249239) (-1.1860663e-05, -0.00024959364) (-1.2045594e-05, -0.00024993962) (-1.2247279e-05, -0.00025027611) (-1.2465232e-05, -0.0002506023) (-1.2698928e-05, -0.0002509174) (-1.2947803e-05, -0.00025122066) (-1.3211259e-05, -0.00025151134) (-1.348866e-05, -0.00025178874) (-1.3779339e-05, -0.0002520522) (-1.4082595e-05, -0.00025230107) (-1.4397697e-05, -0.00025253477) (-1.4723887e-05, -0.00025275272) (-1.5060378e-05, -0.00025295441) (-1.540636e-05, -0.00025313934) (-1.5760999e-05, -0.00025330707) (-1.6123441e-05, -0.0002534572) (-1.6492814e-05, -0.00025358936) (-1.6868226e-05, -0.00025370324)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, closed, covered)
  pocket_cp_ch3 = polyline(z=0, xy: (0.0001475, -0.000375) (-0.0001475, -0.000375) (-0.00014867621, -0.00037494222) (-0.00014984108, -0.00037476942) (-0.00015098342, -0.00037448328) (-0.0001520922, -0.00037408655) (-0.00015315676, -0.00037358305) (-0.00015416684, -0.00037297763) (-0.00015511272, -0.00037227612) (-0.00015598528, -0.00037148528) (-0.00015677613, -0.00037061272) (-0.00015747764, -0.00036966684) (-0.00015808305, -0.00036865676) (-0.00015858655, -0.0003675922) (-0.00015898328, -0.00036648342) (-0.00015926942, -0.00036534108) (-0.00015944222, -0.00036417621) (-0.0001595, -0.000363) (-0.0001595, -0.00019) (-0.00015944222, -0.00018882379) (-0.00015926942, -0.00018765892) (-0.00015898328, -0.00018651658) (-0.00015858655, -0.0001854078) (-0.00015808305, -0.00018434324) (-0.00015747764, -0.00018333316) (-0.00015677613, -0.00018238728) (-0.00015598528, -0.00018151472) (-0.00015511272, -0.00018072388) (-0.00015416684, -0.00018002237) (-0.00015315676, -0.00017941694) (-0.0001520922, -0.00017891345) (-0.00015098342, -0.00017851672) (-0.00014984108, -0.00017823058) (-0.00014867621, -0.00017805778) (-0.0001475, -0.000178) (0.0001475, -0.000178) (0.00014867621, -0.00017805778) (0.00014984108, -0.00017823058) (0.00015098342, -0.00017851672) (0.0001520922, -0.00017891345) (0.00015315676, -0.00017941694) (0.00015416684, -0.00018002237) (0.00015511272, -0.00018072388) (0.00015598528, -0.00018151472) (0.00015677613, -0.00018238728) (0.00015747764, -0.00018333316) (0.00015808305, -0.00018434324) (0.00015858655, -0.0001854078) (0.00015898328, -0.00018651658) (0.00015926942, -0.00018765892) (0.00015944222, -0.00018882379) (0.0001595, -0.00019) (0.0001595, -0.000363) (0.00015944222, -0.00036417621) (0.00015926942, -0.00036534108) (0.00015898328, -0.00036648342) (0.00015858655, -0.0003675922) (0.00015808305, -0.00036865676) (0.00015747764, -0.00036966684) (0.00015677613, -0.00037061272) (0.00015598528, -0.00037148528) (0.00015511272, -0.00037227612) (0.00015416684, -0.00037297763) (0.00015315676, -0.00037358305) (0.0001520922, -0.00037408655) (0.00015098342, -0.00037448328) (0.00014984108, -0.00037476942) (0.00014867621, -0.00037494222) (0.0001475, -0.000375), closed, covered)
  tap_trace_jf_ch3 = polyline(z=0, xy: (5e-06, -0.001465) (5e-06, -0.00161) (3.55e-05, -0.00161) (3.55e-05, -0.00162) (5e-06, -0.00162) (5e-06, -0.001765) (-5e-06, -0.001765) (-5e-06, -0.001465) (5e-06, -0.001465), closed, covered)
  tap_cut_jf_ch3 = polyline(z=0, xy: (1.1e-05, -0.001465) (1.1e-05, -0.001604) (3.55e-05, -0.001604) (3.55e-05, -0.001626) (1.1e-05, -0.001626) (1.1e-05, -0.001765) (-1.1e-05, -0.001765) (-1.1e-05, -0.001465) (1.1e-05, -0.001465), closed, covered)
  tap_trace_jr_ch3 = polyline(z=0, xy: (0.0001645, -0.00161) (0.000195, -0.00161) (0.000195, -0.001465) (0.000205, -0.001465) (0.000205, -0.001765) (0.000195, -0.001765) (0.000195, -0.00162) (0.0001645, -0.00162) (0.0001645, -0.00161), closed, covered)
  tap_cut_jr_ch3 = polyline(z=0, xy: (0.0001645, -0.001604) (0.000189, -0.001604) (0.000189, -0.001465) (0.000211, -0.001465) (0.000211, -0.001765) (0.000189, -0.001765) (0.000189, -0.001626) (0.0001645, -0.001626) (0.0001645, -0.001604), closed, covered)
  head_a_cj_ch3 = polyline(z=0, xy: (6.75e-05, -0.0016475) (6.7303966e-05, -0.0016474904) (6.7109819e-05, -0.0016474616) (6.6919431e-05, -0.0016474139) (6.6734633e-05, -0.0016473478) (6.6557207e-05, -0.0016472638) (6.638886e-05, -0.0016471629) (6.6231213e-05, -0.001647046) (6.6085786e-05, -0.0016469142) (6.5953979e-05, -0.0016467688) (6.5837061e-05, -0.0016466111) (6.5736157e-05, -0.0016464428) (6.5652241e-05, -0.0016462654) (6.5586119e-05, -0.0016460806) (6.5538429e-05, -0.0016458902) (6.5509631e-05, -0.001645696) (6.55e-05, -0.0016455) (6.55e-05, -0.0015845) (6.5509631e-05, -0.001584304) (6.5538429e-05, -0.0015841098) (6.5586119e-05, -0.0015839194) (6.5652241e-05, -0.0015837346) (6.5736157e-05, -0.0015835572) (6.5837061e-05, -0.0015833889) (6.5953979e-05, -0.0015832312) (6.6085786e-05, -0.0015830858) (6.6231213e-05, -0.001582954) (6.638886e-05, -0.0015828371) (6.6557207e-05, -0.0015827362) (6.6734633e-05, -0.0015826522) (6.6919431e-05, -0.0015825861) (6.7109819e-05, -0.0015825384) (6.7303966e-05, -0.0015825096) (6.75e-05, -0.0015825) (8.85e-05, -0.0015825) (8.8696034e-05, -0.0015825096) (8.8890181e-05, -0.0015825384) (8.9080569e-05, -0.0015825861) (8.9265367e-05, -0.0015826522) (8.9442793e-05, -0.0015827362) (8.961114e-05, -0.0015828371) (8.9768787e-05, -0.001582954) (8.9914214e-05, -0.0015830858) (9.0046021e-05, -0.0015832312) (9.0162939e-05, -0.0015833889) (9.0263843e-05, -0.0015835572) (9.0347759e-05, -0.0015837346) (9.0413881e-05, -0.0015839194) (9.0461571e-05, -0.0015841098) (9.0490369e-05, -0.001584304) (9.05e-05, -0.0015845) (9.05e-05, -0.0016455) (9.0490369e-05, -0.001645696) (9.0461571e-05, -0.0016458902) (9.0413881e-05, -0.0016460806) (9.0347759e-05, -0.0016462654) (9.0263843e-05, -0.0016464428) (9.0162939e-05, -0.0016466111) (9.0046021e-05, -0.0016467688) (8.9914214e-05, -0.0016469142) (8.9768787e-05, -0.001647046) (8.961114e-05, -0.0016471629) (8.9442793e-05, -0.0016472638) (8.9265367e-05, -0.0016473478) (8.9080569e-05, -0.0016474139) (8.8890181e-05, -0.0016474616) (8.8696034e-05, -0.0016474904) (8.85e-05, -0.0016475) (6.75e-05, -0.0016475), closed, covered)
  head_b_cj_ch3 = polyline(z=0, xy: (0.0001115, -0.0016475) (0.00011130397, -0.0016474904) (0.00011110982, -0.0016474616) (0.00011091943, -0.0016474139) (0.00011073463, -0.0016473478) (0.00011055721, -0.0016472638) (0.00011038886, -0.0016471629) (0.00011023121, -0.001647046) (0.00011008579, -0.0016469142) (0.00010995398, -0.0016467688) (0.00010983706, -0.0016466111) (0.00010973616, -0.0016464428) (0.00010965224, -0.0016462654) (0.00010958612, -0.0016460806) (0.00010953843, -0.0016458902) (0.00010950963, -0.001645696) (0.0001095, -0.0016455) (0.0001095, -0.0015845) (0.00010950963, -0.001584304) (0.00010953843, -0.0015841098) (0.00010958612, -0.0015839194) (0.00010965224, -0.0015837346) (0.00010973616, -0.0015835572) (0.00010983706, -0.0015833889) (0.00010995398, -0.0015832312) (0.00011008579, -0.0015830858) (0.00011023121, -0.001582954) (0.00011038886, -0.0015828371) (0.00011055721, -0.0015827362) (0.00011073463, -0.0015826522) (0.00011091943, -0.0015825861) (0.00011110982, -0.0015825384) (0.00011130397, -0.0015825096) (0.0001115, -0.0015825) (0.0001325, -0.0015825) (0.00013269603, -0.0015825096) (0.00013289018, -0.0015825384) (0.00013308057, -0.0015825861) (0.00013326537, -0.0015826522) (0.00013344279, -0.0015827362) (0.00013361114, -0.0015828371) (0.00013376879, -0.001582954) (0.00013391421, -0.0015830858) (0.00013404602, -0.0015832312) (0.00013416294, -0.0015833889) (0.00013426384, -0.0015835572) (0.00013434776, -0.0015837346) (0.00013441388, -0.0015839194) (0.00013446157, -0.0015841098) (0.00013449037, -0.001584304) (0.0001345, -0.0015845) (0.0001345, -0.0016455) (0.00013449037, -0.001645696) (0.00013446157, -0.0016458902) (0.00013441388, -0.0016460806) (0.00013434776, -0.0016462654) (0.00013426384, -0.0016464428) (0.00013416294, -0.0016466111) (0.00013404602, -0.0016467688) (0.00013391421, -0.0016469142) (0.00013376879, -0.001647046) (0.00013361114, -0.0016471629) (0.00013344279, -0.0016472638) (0.00013326537, -0.0016473478) (0.00013308057, -0.0016474139) (0.00013289018, -0.0016474616) (0.00013269603, -0.0016474904) (0.0001325, -0.0016475) (0.0001115, -0.0016475), closed, covered)
  pocket_cj_ch3 = polyline(z=0, xy: (5.15e-05, -0.0016635) (5.1303966e-05, -0.0016634904) (5.1109819e-05, -0.0016634616) (5.0919431e-05, -0.0016634139) (5.0734633e-05, -0.0016633478) (5.0557207e-05, -0.0016632638) (5.038886e-05, -0.0016631629) (5.0231213e-05, -0.001663046) (5.0085786e-05, -0.0016629142) (4.9953979e-05, -0.0016627688) (4.9837061e-05, -0.0016626111) (4.9736157e-05, -0.0016624428) (4.9652241e-05, -0.0016622654) (4.9586119e-05, -0.0016620806) (4.9538429e-05, -0.0016618902) (4.9509631e-05, -0.001661696) (4.95e-05, -0.0016615) (4.95e-05, -0.0015685) (4.9509631e-05, -0.001568304) (4.9538429e-05, -0.0015681098) (4.9586119e-05, -0.0015679194) (4.9652241e-05, -0.0015677346) (4.9736157e-05, -0.0015675572) (4.9837061e-05, -0.0015673889) (4.9953979e-05, -0.0015672312) (5.0085786e-05, -0.0015670858) (5.0231213e-05, -0.001566954) (5.038886e-05, -0.0015668371) (5.0557207e-05, -0.0015667362) (5.0734633e-05, -0.0015666522) (5.0919431e-05, -0.0015665861) (5.1109819e-05, -0.0015665384) (5.1303966e-05, -0.0015665096) (5.15e-05, -0.0015665) (0.0001485, -0.0015665) (0.00014869603, -0.0015665096) (0.00014889018, -0.0015665384) (0.00014908057, -0.0015665861) (0.00014926537, -0.0015666522) (0.00014944279, -0.0015667362) (0.00014961114, -0.0015668371) (0.00014976879, -0.001566954) (0.00014991421, -0.0015670858) (0.00015004602, -0.0015672312) (0.00015016294, -0.0015673889) (0.00015026384, -0.0015675572) (0.00015034776, -0.0015677346) (0.00015041388, -0.0015679194) (0.00015046157, -0.0015681098) (0.00015049037, -0.001568304) (0.0001505, -0.0015685) (0.0001505, -0.0016615) (0.00015049037, -0.001661696) (0.00015046157, -0.0016618902) (0.00015041388, -0.0016620806) (0.00015034776, -0.0016622654) (0.00015026384, -0.0016624428) (0.00015016294, -0.0016626111) (0.00015004602, -0.0016627688) (0.00014991421, -0.0016629142) (0.00014976879, -0.001663046) (0.00014961114, -0.0016631629) (0.00014944279, -0.0016632638) (0.00014926537, -0.0016633478) (0.00014908057, -0.0016634139) (0.00014889018, -0.0016634616) (0.00014869603, -0.0016634904) (0.0001485, -0.0016635) (5.15e-05, -0.0016635), closed, covered)
  endcap_res_a_ch3_start = rectangle(corner=(0.000189, -0.002921, 0), x_size=2.2e-05, y_size=6e-06)
  endcap_feed_in_start = rectangle(corner=(-0.001176, -1.1e-05, 0), x_size=6e-06, y_size=2.2e-05)
  endcap_feed_out_end = rectangle(corner=(0.00117, -1.1e-05, 0), x_size=6e-06, y_size=2.2e-05)
  ground_main_plane = rectangle(corner=(-0.00137, -0.003115, 0), x_size=0.00274, y_size=0.003326)
  main [silicon] = box(corner=(-0.00137, -0.003115, -0.000525), size=(0.00274, 0.003326, 0.000525))
  sample_holder [vacuum] = box(corner=(-0.00137, -0.003115, -0.00165), size=(0.00274, 0.003326, 0.00254))
  ground_main_plane.subtract(tap_cut_n0_ch3, cut_stub_p_ch3, cut_res_a_ch3, lead_b_sub_cj_ch3, lead_a_sub_cj_ch3, lead_a_sub_cp_ch3, endcap_res_a_ch3_start, endcap_feed_out_end, cut_res_ch3, tap_cut_jr_ch3, cut_filt_ch3, cut_feed_out, cut_stub_f_ch3, pocket_cj_ch3, cut_feed_jf_ch3, endcap_feed_in_start, lead_b_sub_cp_ch3, tap_cut_jf_ch3, pocket_cp_ch3, cut_feed_in, cut_stub_r_ch3)
  Port_feed_in_start = rectangle(corner=(-0.001176, -5e-06, 0), x_size=6e-06, y_size=1e-05)
  voltage_line_Port_feed_in_start = polyline((-0.00117, 0, 0) (-0.001176, 0, 0))
  Port_feed_out_end = rectangle(corner=(0.00117, -5e-06, 0), x_size=6e-06, y_size=1e-05)
  voltage_line_Port_feed_out_end = polyline((0.00117, 0, 0) (0.001176, 0, 0))
boundaries and excitations:
  PerfE: Perfect E Objects=[lead_a_cp_ch3, lead_b_cp_ch3, trace_stub_p_ch3, trace_feed_jf_ch3, lead_a_cj_ch3, lead_b_cj_ch3, trace_stub_f_ch3, trace_stub_r_ch3, trace_res_a_ch3, trace_filt_ch3, trace_res_ch3, trace_feed_in, trace_feed_out, tap_trace_n0_ch3, plate_cp_ch3, frame_cp_ch3, tap_trace_jf_ch3, tap_trace_jr_ch3, head_a_cj_ch3, head_b_cj_ch3, ground_main_plane]
  LumpPort_feed_in_start: Lumped Port Objects=Port_feed_in_start Modes{Mode1{IntLine{middle of Port_feed_in_start.edge(x at corner) -> middle of Port_feed_in_start.edge(x opposite corner)} CharImp=Zpi RenormImp=50ohm}} Impedance=50ohm
  LumpPort_feed_out_end: Lumped Port Objects=Port_feed_out_end Modes{Mode1{IntLine{middle of Port_feed_out_end.edge(x at corner) -> middle of Port_feed_out_end.edge(x opposite corner)} CharImp=Zpi RenormImp=50ohm}} Impedance=50ohm
setups:
  Setup: HfssDriven Frequency=6.71GHz MaxDeltaS=0.003 MaximumPasses=1 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=10 MeshLink{ImportMesh LinkID=413 Project="This Project*" Product=HFSS Design=v6_full_eig_1611_hfss PathRelativeTo=SourceProduct ApplyMeshOp} BasisOrder=2 DoLambdaRefine=false PortAccuracy=2
    sweep Sweep: 6.1GHz to 6.9GHz, 3201 points; Type=Fast
source amplitudes:
  LumpPort_feed_in_start:1: 1W 0deg
  LumpPort_feed_out_end:1: 0W 0deg
field plots:
  Mesh1: MeshPlots in main on Setup : LastAdaptive at Freq=6.71GHz Phase=0deg
reports:
  S Parameter Plot 1: dB(S(LumpPort_feed_in_start,LumpPort_feed_in_start)), dB(S(LumpPort_feed_out_end,LumpPort_feed_in_start)), dB(S(LumpPort_feed_in_start,LumpPort_feed_out_end)), dB(S(LumpPort_feed_out_end,LumpPort_feed_out_end)) vs Freq on Setup : Sweep

design q3d6_full_1957_q3d (Q3D Extractor, model units mm)
options: SParamCalcMethod=EqTransLine Calculate_Lossy_Dielectrics
geometry:
  lead_a_cp_ch3_path = polyline((0, -0.000362999, 0) (0, -0.000415, 0))
  lead_a_cp_ch3 [copper] = polyline((5e-06, -0.000362999, 0) (-5e-06, -0.000362999, 0))
  lead_a_cp_ch3.sweep_along_path(lead_a_cp_ch3_path)
  lead_a_sub_cp_ch3_path = polyline((0, -0.000362999, 0) (0, -0.000415, 0))
  lead_a_sub_cp_ch3 = polyline((1.1e-05, -0.000362999, 0) (-1.1e-05, -0.000362999, 0))
  lead_a_sub_cp_ch3.sweep_along_path(lead_a_sub_cp_ch3_path)
  lead_b_cp_ch3_path = polyline((0, -0.000262001, 0) (0, -0.00015, 0))
  lead_b_cp_ch3 [copper] = polyline((-5e-06, -0.000262001, 0) (5e-06, -0.000262001, 0))
  lead_b_cp_ch3.sweep_along_path(lead_b_cp_ch3_path)
  lead_b_sub_cp_ch3_path = polyline((0, -0.000262001, 0) (0, -0.00015, 0))
  lead_b_sub_cp_ch3 = polyline((-1.1e-05, -0.000262001, 0) (1.1e-05, -0.000262001, 0))
  lead_b_sub_cp_ch3.sweep_along_path(lead_b_sub_cp_ch3_path)
  trace_stub_p_ch3_path = polyline((0, -0.0001, 0) (0, -0.00015, 0))
  trace_stub_p_ch3 [copper] = polyline((5e-06, -0.0001, 0) (-5e-06, -0.0001, 0))
  trace_stub_p_ch3.sweep_along_path(trace_stub_p_ch3_path)
  cut_stub_p_ch3_path = polyline((0, -0.0001, 0) (0, -0.00015, 0))
  cut_stub_p_ch3 = polyline((1.1e-05, -0.0001, 0) (-1.1e-05, -0.0001, 0))
  cut_stub_p_ch3.sweep_along_path(cut_stub_p_ch3_path)
  trace_feed_jf_ch3_path = polyline((0, -0.000415, 0) (0, -0.001465, 0))
  trace_feed_jf_ch3 [copper] = polyline((5e-06, -0.000415, 0) (-5e-06, -0.000415, 0))
  trace_feed_jf_ch3.sweep_along_path(trace_feed_jf_ch3_path)
  cut_feed_jf_ch3_path = polyline((0, -0.000415, 0) (0, -0.001465, 0))
  cut_feed_jf_ch3 = polyline((1.1e-05, -0.000415, 0) (-1.1e-05, -0.000415, 0))
  cut_feed_jf_ch3.sweep_along_path(cut_feed_jf_ch3_path)
  lead_a_cj_ch3_path = polyline((6.5501e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  lead_a_cj_ch3 [copper] = polyline((6.5501e-05, -0.00162, 0) (6.5501e-05, -0.00161, 0))
  lead_a_cj_ch3.sweep_along_path(lead_a_cj_ch3_path)
  lead_a_sub_cj_ch3_path = polyline((6.5501e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  lead_a_sub_cj_ch3 = polyline((6.5501e-05, -0.001626, 0) (6.5501e-05, -0.001604, 0))
  lead_a_sub_cj_ch3.sweep_along_path(lead_a_sub_cj_ch3_path)
  lead_b_cj_ch3_path = polyline((0.000134499, -0.001615, 0) (0.0001445, -0.001615, 0))
  lead_b_cj_ch3 [copper] = polyline((0.000134499, -0.00161, 0) (0.000134499, -0.00162, 0))
  lead_b_cj_ch3.sweep_along_path(lead_b_cj_ch3_path)
  lead_b_sub_cj_ch3_path = polyline((0.000134499, -0.001615, 0) (0.0001445, -0.001615, 0))
  lead_b_sub_cj_ch3 = polyline((0.000134499, -0.001604, 0) (0.000134499, -0.001626, 0))
  lead_b_sub_cj_ch3.sweep_along_path(lead_b_sub_cj_ch3_path)
  trace_stub_f_ch3_path = polyline((3.55e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  trace_stub_f_ch3 [copper] = polyline((3.55e-05, -0.00161, 0) (3.55e-05, -0.00162, 0))
  trace_stub_f_ch3.sweep_along_path(trace_stub_f_ch3_path)
  cut_stub_f_ch3_path = polyline((3.55e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  cut_stub_f_ch3 = polyline((3.55e-05, -0.001604, 0) (3.55e-05, -0.001626, 0))
  cut_stub_f_ch3.sweep_along_path(cut_stub_f_ch3_path)
  trace_stub_r_ch3_path = polyline((0.0001645, -0.001615, 0) (0.0001445, -0.001615, 0))
  trace_stub_r_ch3 [copper] = polyline((0.0001645, -0.00162, 0) (0.0001645, -0.00161, 0))
  trace_stub_r_ch3.sweep_along_path(trace_stub_r_ch3_path)
  cut_stub_r_ch3_path = polyline((0.0001645, -0.001615, 0) (0.0001445, -0.001615, 0))
  cut_stub_r_ch3 = polyline((0.0001645, -0.001626, 0) (0.0001645, -0.001604, 0))
  cut_stub_r_ch3.sweep_along_path(cut_stub_r_ch3_path)
  trace_res_a_ch3_path = polyline((0.0002, -0.002915, 0) (0.0002, -0.001765, 0))
  trace_res_a_ch3 [copper] = polyline((0.000195, -0.002915, 0) (0.000205, -0.002915, 0))
  trace_res_a_ch3.sweep_along_path(trace_res_a_ch3_path)
  cut_res_a_ch3_path = polyline((0.0002, -0.002915, 0) (0.0002, -0.001765, 0))
  cut_res_a_ch3 = polyline((0.000189, -0.002915, 0) (0.000211, -0.002915, 0))
  cut_res_a_ch3.sweep_along_path(cut_res_a_ch3_path)
  trace_filt_ch3_path = polyline(z=0, xy: (-0.0003, -0.000915) (-0.0003, -0.0022822498) (0, -0.0022822498) (0, -0.001765))
  trace_filt_ch3_path.fillet(Vertices=trace_filt_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  trace_filt_ch3 [copper] = polyline((-0.000295, -0.000915, 0) (-0.000305, -0.000915, 0))
  trace_filt_ch3.sweep_along_path(trace_filt_ch3_path)
  cut_filt_ch3_path = polyline(z=0, xy: (-0.0003, -0.000915) (-0.0003, -0.0022822498) (0, -0.0022822498) (0, -0.001765))
  cut_filt_ch3_path.fillet(Vertices=cut_filt_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  cut_filt_ch3 = polyline((-0.000289, -0.000915, 0) (-0.000311, -0.000915, 0))
  cut_filt_ch3.sweep_along_path(cut_filt_ch3_path)
  trace_res_ch3_path = polyline(z=0, xy: (0.00055, -0.00255234) (0.00055, -0.000665) (0.0002, -0.000665) (0.0002, -0.001465))
  trace_res_ch3_path.fillet(Vertices=trace_res_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  trace_res_ch3 [copper] = polyline((0.000545, -0.00255234, 0) (0.000555, -0.00255234, 0))
  trace_res_ch3.sweep_along_path(trace_res_ch3_path)
  cut_res_ch3_path = polyline(z=0, xy: (0.00055, -0.00255234) (0.00055, -0.000665) (0.0002, -0.000665) (0.0002, -0.001465))
  cut_res_ch3_path.fillet(Vertices=cut_res_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  cut_res_ch3 = polyline((0.000539, -0.00255234, 0) (0.000561, -0.00255234, 0))
  cut_res_ch3.sweep_along_path(cut_res_ch3_path)
  trace_feed_in_path = polyline((-0.00117, 0, 0) (-0.00015, 0, 0))
  trace_feed_in [copper] = polyline((-0.00117, 5e-06, 0) (-0.00117, -5e-06, 0))
  trace_feed_in.sweep_along_path(trace_feed_in_path)
  cut_feed_in_path = polyline((-0.00117, 0, 0) (-0.00015, 0, 0))
  cut_feed_in = polyline((-0.00117, 1.1e-05, 0) (-0.00117, -1.1e-05, 0))
  cut_feed_in.sweep_along_path(cut_feed_in_path)
  trace_feed_out_path = polyline((0.00015, 0, 0) (0.00117, 0, 0))
  trace_feed_out [copper] = polyline((0.00015, 5e-06, 0) (0.00015, -5e-06, 0))
  trace_feed_out.sweep_along_path(trace_feed_out_path)
  cut_feed_out_path = polyline((0.00015, 0, 0) (0.00117, 0, 0))
  cut_feed_out = polyline((0.00015, 1.1e-05, 0) (0.00015, -1.1e-05, 0))
  cut_feed_out.sweep_along_path(cut_feed_out_path)
  g_wb [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-5.5e-05 YPadPos=-0.000765 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_1 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-5.5e-05 YPadPos=-0.001115 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_2 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000255 YPadPos=-0.0025316667 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_3 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000255 YPadPos=-0.0021483333 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_4 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0012568124 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_5 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0015986249 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_6 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0019404373 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_7 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=5.5e-05 YPadPos=-0.0020236249 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_8 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.002174872 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_9 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001797404 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_10 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001419936 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_11 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001042468 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_12 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000145 YPadPos=-0.00093166667 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_13 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000145 YPadPos=-0.0011983333 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_14 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00083 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_15 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00049 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_16 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00049 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_17 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00083 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  launch_pad_LPPin [copper] = polyline(z=0, xy: (-0.0012, 5e-06) (-0.001322, 0.0001) (-0.001522, 0.0001) (-0.001522, -0.0001) (-0.001322, -0.0001) (-0.0012, -5e-06) (-0.00117, -5e-06) (-0.00117, 5e-06) (-0.0012, 5e-06), closed, covered)
  pocket_LPPin = polyline(z=0, xy: (-0.0012, 1.1e-05) (-0.001322, 0.0001765) (-0.0015985, 0.0001765) (-0.0015985, -0.0001765) (-0.001322, -0.0001765) (-0.0012, -1.1e-05) (-0.00117, -1.1e-05) (-0.00117, 1.1e-05) (-0.0012, 1.1e-05), closed, covered)
  launch_pad_LPPout [copper] = polyline(z=0, xy: (0.0012, -5e-06) (0.001322, -0.0001) (0.001522, -0.0001) (0.001522, 0.0001) (0.001322, 0.0001) (0.0012, 5e-06) (0.00117, 5e-06) (0.00117, -5e-06) (0.0012, -5e-06), closed, covered)
  pocket_LPPout = polyline(z=0, xy: (0.0012, -1.1e-05) (0.001322, -0.0001765) (0.0015985, -0.0001765) (0.0015985, 0.0001765) (0.001322, 0.0001765) (0.0012, 1.1e-05) (0.00117, 1.1e-05) (0.00117, -1.1e-05) (0.0012, -1.1e-05), closed, covered)
  tap_trace_n0_ch3 [copper] = polyline(z=0, xy: (-5e-06, -0.0001) (-5e-06, -5e-06) (-0.00015, -5e-06) (-0.00015, 5e-06) (0.00015, 5e-06) (0.00015, -5e-06) (5e-06, -5e-06) (5e-06, -0.0001) (-5e-06, -0.0001), closed, covered)
  tap_cut_n0_ch3 = polyline(z=0, xy: (-1.1e-05, -0.0001) (-1.1e-05, -1.1e-05) (-0.00015, -1.1e-05) (-0.00015, 1.1e-05) (0.00015, 1.1e-05) (0.00015, -1.1e-05) (1.1e-05, -1.1e-05) (1.1e-05, -0.0001) (-1.1e-05, -0.0001), closed, covered)
  plate_cp_ch3 [copper] = polyline(z=0, xy: (8.25e-05, -0.000295) (8.2461478e-05, -0.00029578414) (8.2346282e-05, -0.00029656072) (8.2155523e-05, -0.00029732228) (8.1891036e-05, -0.00029806147) (8.155537e-05, -0.00029877117) (8.1151757e-05, -0.00029944456) (8.0684084e-05, -0.00030007515) (8.0156854e-05, -0.00030065685) (7.9575146e-05, -0.00030118408) (7.8944562e-05, -0.00030165176) (7.8271174e-05, -0.00030205537) (7.7561467e-05, -0.00030239104) (7.6822277e-05, -0.00030265552) (7.6060723e-05, -0.00030284628) (7.5284137e-05, -0.00030296148) (7.45e-05, -0.000303) (-7.45e-05, -0.000303) (-7.5284137e-05, -0.00030296148) (-7.6060723e-05, -0.00030284628) (-7.6822277e-05, -0.00030265552) (-7.7561467e-05, -0.00030239104) (-7.8271174e-05, -0.00030205537) (-7.8944562e-05, -0.00030165176) (-7.9575146e-05, -0.00030118408) (-8.0156854e-05, -0.00030065685) (-8.0684084e-05, -0.00030007515) (-8.1151757e-05, -0.00029944456) (-8.155537e-05, -0.00029877117) (-8.1891036e-05, -0.00029806147) (-8.2155523e-05, -0.00029732228) (-8.2346282e-05, -0.00029656072) (-8.2461478e-05, -0.00029578414) (-8.25e-05, -0.000295) (-8.25e-05, -0.00027) (-8.2461478e-05, -0.00026921586) (-8.2346282e-05, -0.00026843928) (-8.2155523e-05, -0.00026767772) (-8.1891036e-05, -0.00026693853) (-8.155537e-05, -0.00026622883) (-8.1151757e-05, -0.00026555544) (-8.0684084e-05, -0.00026492485) (-8.0156854e-05, -0.00026434315) (-7.9575146e-05, -0.00026381592) (-7.8944562e-05, -0.00026334824) (-7.8271174e-05, -0.00026294463) (-7.7561467e-05, -0.00026260896) (-7.6822277e-05, -0.00026234448) (-7.6060723e-05, -0.00026215372) (-7.5284137e-05, -0.00026203852) (-7.45e-05, -0.000262) (7.45e-05, -0.000262) (7.5284137e-05, -0.00026203852) (7.6060723e-05, -0.00026215372) (7.6822277e-05, -0.00026234448) (7.7561467e-05, -0.00026260896) (7.8271174e-05, -0.00026294463) (7.8944562e-05, -0.00026334824) (7.9575146e-05, -0.00026381592) (8.0156854e-05, -0.00026434315) (8.0684084e-05, -0.00026492485) (8.1151757e-05, -0.00026555544) (8.155537e-05, -0.00026622883) (8.1891036e-05, -0.00026693853) (8.2155523e-05, -0.00026767772) (8.2346282e-05, -0.00026843928) (8.2461478e-05, -0.00026921586) (8.25e-05, -0.00027) (8.25e-05, -0.000295), closed, covered)
  frame_cp_ch3 [copper] = polyline(z=0, xy: (8.25e-05, -0.000311) (8.3284137e-05, -0.00031096148) (8.4060723e-05, -0.00031084628) (8.4822277e-05, -0.00031065552) (8.5561467e-05, -0.00031039104) (8.6271174e-05, -0.00031005537) (8.6944562e-05, -0.00030965176) (8.7575146e-05, -0.00030918408) (8.8156854e-05, -0.00030865685) (8.8684084e-05, -0.00030807515) (8.9151757e-05, -0.00030744456) (8.955537e-05, -0.00030677117) (8.9891036e-05, -0.00030606147) (9.0155523e-05, -0.00030532228) (9.0346282e-05, -0.00030456072) (9.0461478e-05, -0.00030378414) (9.05e-05, -0.000303) (9.05e-05, -0.000262) (9.0461478e-05, -0.00026121586) (9.0346282e-05, -0.00026043928) (9.0155523e-05, -0.00025967772) (8.9891036e-05, -0.00025893853) (8.955537e-05, -0.00025822883) (8.9151757e-05, -0.00025755544) (8.8684084e-05, -0.00025692485) (8.8156854e-05, -0.00025634315) (8.7575146e-05, -0.00025581592) (8.6944562e-05, -0.00025534824) (8.6271174e-05, -0.00025494463) (8.5561467e-05, -0.00025460896) (8.4822277e-05, -0.00025434448) (8.4060723e-05, -0.00025415372) (8.3284137e-05, -0.00025403852) (8.25e-05, -0.000254) (1.909818e-05, -0.000254) (1.8901939e-05, -0.00025399518) (1.8412015e-05, -0.00025397111) (1.80216e-05, -0.00025393266) (1.7633541e-05, -0.0002538751) (1.7248774e-05, -0.00025379856) (1.6868226e-05, -0.00025370324) (1.6492814e-05, -0.00025358936) (1.6123441e-05, -0.0002534572) (1.5760999e-05, -0.00025330707) (1.540636e-05, -0.00025313934) (1.5060378e-05, -0.00025295441) (1.4723887e-05, -0.00025275272) (1.4397697e-05, -0.00025253477) (1.4082595e-05, -0.00025230107) (1.3779339e-05, -0.0002520522) (1.348866e-05, -0.00025178874) (1.3211259e-05, -0.00025151134) (1.2947803e-05, -0.00025122066) (1.2698928e-05, -0.0002509174) (1.2465232e-05, -0.0002506023) (1.2247279e-05, -0.00025027611) (1.2045594e-05, -0.00024993962) (1.1860663e-05, -0.00024959364) (1.1692931e-05, -0.000249239) (1.1542802e-05, -0.00024887656) (1.1410639e-05, -0.00024850719) (1.1296759e-05, -0.00024813177) (1.1201436e-05, -0.00024775123) (1.1124902e-05, -0.00024736646) (1.1067338e-05, -0.0002469784) (1.1028886e-05, -0.00024658799) (1.1004817e-05, -0.00024609806) (1.1e-05, -0.00024590182) (1.1e-05, -0.00019809818) (1.1004817e-05, -0.00019790194) (1.1028886e-05, -0.00019741201) (1.1067338e-05, -0.0001970216) (1.1124902e-05, -0.00019663354) (1.1201436e-05, -0.00019624877) (1.1296759e-05, -0.00019586823) (1.1410639e-05, -0.00019549281) (1.1542802e-05, -0.00019512344) (1.1692931e-05, -0.000194761) (1.1860663e-05, -0.00019440636) (1.2045594e-05, -0.00019406038) (1.2247279e-05, -0.00019372389) (1.2465232e-05, -0.0001933977) (1.2698928e-05, -0.00019308259) (1.2947803e-05, -0.00019277934) (1.3211259e-05, -0.00019248866) (1.348866e-05, -0.00019221126) (1.3779339e-05, -0.0001919478) (1.4082595e-05, -0.00019169893) (1.4397697e-05, -0.00019146523) (1.4723887e-05, -0.00019124728) (1.5060378e-05, -0.00019104559) (1.540636e-05, -0.00019086066) (1.5760999e-05, -0.00019069293) (1.6123441e-05, -0.0001905428) (1.6492814e-05, -0.00019041064) (1.6868226e-05, -0.00019029676) (1.7248774e-05, -0.00019020144) (1.7633541e-05, -0.0001901249) (1.80216e-05, -0.00019006734) (1.8412015e-05, -0.00019002889) (1.8901939e-05, -0.00019000482) (1.909818e-05, -0.00019) (0.00013940182, -0.00019) (0.00013959806, -0.00019000482) (0.00014008798, -0.00019002889) (0.0001404784, -0.00019006734) (0.00014086646, -0.0001901249) (0.00014125123, -0.00019020144) (0.00014163177, -0.00019029676) (0.00014200719, -0.00019041064) (0.00014237656, -0.0001905428) (0.000142739, -0.00019069293) (0.00014309364, -0.00019086066) (0.00014343962, -0.00019104559) (0.00014377611, -0.00019124728) (0.0001441023, -0.00019146523) (0.0001444174, -0.00019169893) (0.00014472066, -0.0001919478) (0.00014501134, -0.00019221126) (0.00014528874, -0.00019248866) (0.0001455522, -0.00019277934) (0.00014580107, -0.00019308259) (0.00014603477, -0.0001933977) (0.00014625272, -0.00019372389) (0.00014645441, -0.00019406038) (0.00014663934, -0.00019440636) (0.00014680707, -0.000194761) (0.0001469572, -0.00019512344) (0.00014708936, -0.00019549281) (0.00014720324, -0.00019586823) (0.00014729856, -0.00019624877) (0.0001473751, -0.00019663354) (0.00014743266, -0.0001970216) (0.00014747111, -0.00019741201) (0.00014749518, -0.00019790194) (0.0001475, -0.00019809818) (0.0001475, -0.00035490182) (0.00014749518, -0.00035509806) (0.00014747111, -0.00035558799) (0.00014743266, -0.0003559784) (0.0001473751, -0.00035636646) (0.00014729856, -0.00035675123) (0.00014720324, -0.00035713177) (0.00014708936, -0.00035750719) (0.0001469572, -0.00035787656) (0.00014680707, -0.000358239) (0.00014663934, -0.00035859364) (0.00014645441, -0.00035893962) (0.00014625272, -0.00035927611) (0.00014603477, -0.0003596023) (0.00014580107, -0.00035991741) (0.0001455522, -0.00036022066) (0.00014528874, -0.00036051134) (0.00014501134, -0.00036078874) (0.00014472066, -0.0003610522) (0.0001444174, -0.00036130107) (0.0001441023, -0.00036153477) (0.00014377611, -0.00036175272) (0.00014343962, -0.00036195441) (0.00014309364, -0.00036213934) (0.000142739, -0.00036230707) (0.00014237656, -0.0003624572) (0.00014200719, -0.00036258936) (0.00014163177, -0.00036270324) (0.00014125123, -0.00036279856) (0.00014086646, -0.0003628751) (0.0001404784, -0.00036293266) (0.00014008798, -0.00036297111) (0.00013959806, -0.00036299518) (0.00013940182, -0.000363) (-0.00013940182, -0.000363) (-0.00013959806, -0.00036299518) (-0.00014008798, -0.00036297111) (-0.0001404784, -0.00036293266) (-0.00014086646, -0.0003628751) (-0.00014125123, -0.00036279856) (-0.00014163177, -0.00036270324) (-0.00014200719, -0.00036258936) (-0.00014237656, -0.0003624572) (-0.000142739, -0.00036230707) (-0.00014309364, -0.00036213934) (-0.00014343962, -0.00036195441) (-0.00014377611, -0.00036175272) (-0.0001441023, -0.00036153477) (-0.0001444174, -0.00036130107) (-0.00014472066, -0.0003610522) (-0.00014501134, -0.00036078874) (-0.00014528874, -0.00036051134) (-0.0001455522, -0.00036022066) (-0.00014580107, -0.00035991741) (-0.00014603477, -0.0003596023) (-0.00014625272, -0.00035927611) (-0.00014645441, -0.00035893962) (-0.00014663934, -0.00035859364) (-0.00014680707, -0.000358239) (-0.0001469572, -0.00035787656) (-0.00014708936, -0.00035750719) (-0.00014720324, -0.00035713177) (-0.00014729856, -0.00035675123) (-0.0001473751, -0.00035636646) (-0.00014743266, -0.0003559784) (-0.00014747111, -0.00035558799) (-0.00014749518, -0.00035509806) (-0.0001475, -0.00035490182) (-0.0001475, -0.00019809818) (-0.00014749518, -0.00019790194) (-0.00014747111, -0.00019741201) (-0.00014743266, -0.0001970216) (-0.0001473751, -0.00019663354) (-0.00014729856, -0.00019624877) (-0.00014720324, -0.00019586823) (-0.00014708936, -0.00019549281) (-0.0001469572, -0.00019512344) (-0.00014680707, -0.000194761) (-0.00014663934, -0.00019440636) (-0.00014645441, -0.00019406038) (-0.00014625272, -0.00019372389) (-0.00014603477, -0.0001933977) (-0.00014580107, -0.00019308259) (-0.0001455522, -0.00019277934) (-0.00014528874, -0.00019248866) (-0.00014501134, -0.00019221126) (-0.00014472066, -0.0001919478) (-0.0001444174, -0.00019169893) (-0.0001441023, -0.00019146523) (-0.00014377611, -0.00019124728) (-0.00014343962, -0.00019104559) (-0.00014309364, -0.00019086066) (-0.000142739, -0.00019069293) (-0.00014237656, -0.0001905428) (-0.00014200719, -0.00019041064) (-0.00014163177, -0.00019029676) (-0.00014125123, -0.00019020144) (-0.00014086646, -0.0001901249) (-0.0001404784, -0.00019006734) (-0.00014008798, -0.00019002889) (-0.00013959806, -0.00019000482) (-0.00013940182, -0.00019) (-1.909818e-05, -0.00019) (-1.8901939e-05, -0.00019000482) (-1.8412015e-05, -0.00019002889) (-1.80216e-05, -0.00019006734) (-1.7633541e-05, -0.0001901249) (-1.7248774e-05, -0.00019020144) (-1.6868226e-05, -0.00019029676) (-1.6492814e-05, -0.00019041064) (-1.6123441e-05, -0.0001905428) (-1.5760999e-05, -0.00019069293) (-1.540636e-05, -0.00019086066) (-1.5060378e-05, -0.00019104559) (-1.4723887e-05, -0.00019124728) (-1.4397697e-05, -0.00019146523) (-1.4082595e-05, -0.00019169893) (-1.3779339e-05, -0.0001919478) (-1.348866e-05, -0.00019221126) (-1.3211259e-05, -0.00019248866) (-1.2947803e-05, -0.00019277934) (-1.2698928e-05, -0.00019308259) (-1.2465232e-05, -0.0001933977) (-1.2247279e-05, -0.00019372389) (-1.2045594e-05, -0.00019406038) (-1.1860663e-05, -0.00019440636) (-1.1692931e-05, -0.000194761) (-1.1542802e-05, -0.00019512344) (-1.1410639e-05, -0.00019549281) (-1.1296759e-05, -0.00019586823) (-1.1201436e-05, -0.00019624877) (-1.1124902e-05, -0.00019663354) (-1.1067338e-05, -0.0001970216) (-1.1028886e-05, -0.00019741201) (-1.1004817e-05, -0.00019790194) (-1.1e-05, -0.00019809818) (-1.1e-05, -0.00024590182) (-1.1004817e-05, -0.00024609806) (-1.1028886e-05, -0.00024658799) (-1.1067338e-05, -0.0002469784) (-1.1124902e-05, -0.00024736646) (-1.1201436e-05, -0.00024775123) (-1.1296759e-05, -0.00024813177) (-1.1410639e-05, -0.00024850719) (-1.1542802e-05, -0.00024887656) (-1.1692931e-05, -0.000249239) (-1.1860663e-05, -0.00024959364) (-1.2045594e-05, -0.00024993962) (-1.2247279e-05, -0.00025027611) (-1.2465232e-05, -0.0002506023) (-1.2698928e-05, -0.0002509174) (-1.2947803e-05, -0.00025122066) (-1.3211259e-05, -0.00025151134) (-1.348866e-05, -0.00025178874) (-1.3779339e-05, -0.0002520522) (-1.4082595e-05, -0.00025230107) (-1.4397697e-05, -0.00025253477) (-1.4723887e-05, -0.00025275272) (-1.5060378e-05, -0.00025295441) (-1.540636e-05, -0.00025313934) (-1.5760999e-05, -0.00025330707) (-1.6123441e-05, -0.0002534572) (-1.6492814e-05, -0.00025358936) (-1.6868226e-05, -0.00025370324)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, closed, covered)
  pocket_cp_ch3 = polyline(z=0, xy: (0.0001475, -0.000375) (-0.0001475, -0.000375) (-0.00014867621, -0.00037494222) (-0.00014984108, -0.00037476942) (-0.00015098342, -0.00037448328) (-0.0001520922, -0.00037408655) (-0.00015315676, -0.00037358305) (-0.00015416684, -0.00037297763) (-0.00015511272, -0.00037227612) (-0.00015598528, -0.00037148528) (-0.00015677613, -0.00037061272) (-0.00015747764, -0.00036966684) (-0.00015808305, -0.00036865676) (-0.00015858655, -0.0003675922) (-0.00015898328, -0.00036648342) (-0.00015926942, -0.00036534108) (-0.00015944222, -0.00036417621) (-0.0001595, -0.000363) (-0.0001595, -0.00019) (-0.00015944222, -0.00018882379) (-0.00015926942, -0.00018765892) (-0.00015898328, -0.00018651658) (-0.00015858655, -0.0001854078) (-0.00015808305, -0.00018434324) (-0.00015747764, -0.00018333316) (-0.00015677613, -0.00018238728) (-0.00015598528, -0.00018151472) (-0.00015511272, -0.00018072388) (-0.00015416684, -0.00018002237) (-0.00015315676, -0.00017941694) (-0.0001520922, -0.00017891345) (-0.00015098342, -0.00017851672) (-0.00014984108, -0.00017823058) (-0.00014867621, -0.00017805778) (-0.0001475, -0.000178) (0.0001475, -0.000178) (0.00014867621, -0.00017805778) (0.00014984108, -0.00017823058) (0.00015098342, -0.00017851672) (0.0001520922, -0.00017891345) (0.00015315676, -0.00017941694) (0.00015416684, -0.00018002237) (0.00015511272, -0.00018072388) (0.00015598528, -0.00018151472) (0.00015677613, -0.00018238728) (0.00015747764, -0.00018333316) (0.00015808305, -0.00018434324) (0.00015858655, -0.0001854078) (0.00015898328, -0.00018651658) (0.00015926942, -0.00018765892) (0.00015944222, -0.00018882379) (0.0001595, -0.00019) (0.0001595, -0.000363) (0.00015944222, -0.00036417621) (0.00015926942, -0.00036534108) (0.00015898328, -0.00036648342) (0.00015858655, -0.0003675922) (0.00015808305, -0.00036865676) (0.00015747764, -0.00036966684) (0.00015677613, -0.00037061272) (0.00015598528, -0.00037148528) (0.00015511272, -0.00037227612) (0.00015416684, -0.00037297763) (0.00015315676, -0.00037358305) (0.0001520922, -0.00037408655) (0.00015098342, -0.00037448328) (0.00014984108, -0.00037476942) (0.00014867621, -0.00037494222) (0.0001475, -0.000375), closed, covered)
  tap_trace_jf_ch3 [copper] = polyline(z=0, xy: (5e-06, -0.001465) (5e-06, -0.00161) (3.55e-05, -0.00161) (3.55e-05, -0.00162) (5e-06, -0.00162) (5e-06, -0.001765) (-5e-06, -0.001765) (-5e-06, -0.001465) (5e-06, -0.001465), closed, covered)
  tap_cut_jf_ch3 = polyline(z=0, xy: (1.1e-05, -0.001465) (1.1e-05, -0.001604) (3.55e-05, -0.001604) (3.55e-05, -0.001626) (1.1e-05, -0.001626) (1.1e-05, -0.001765) (-1.1e-05, -0.001765) (-1.1e-05, -0.001465) (1.1e-05, -0.001465), closed, covered)
  tap_trace_jr_ch3 [copper] = polyline(z=0, xy: (0.0001645, -0.00161) (0.000195, -0.00161) (0.000195, -0.001465) (0.000205, -0.001465) (0.000205, -0.001765) (0.000195, -0.001765) (0.000195, -0.00162) (0.0001645, -0.00162) (0.0001645, -0.00161), closed, covered)
  tap_cut_jr_ch3 = polyline(z=0, xy: (0.0001645, -0.001604) (0.000189, -0.001604) (0.000189, -0.001465) (0.000211, -0.001465) (0.000211, -0.001765) (0.000189, -0.001765) (0.000189, -0.001626) (0.0001645, -0.001626) (0.0001645, -0.001604), closed, covered)
  head_a_cj_ch3 [copper] = polyline(z=0, xy: (6.75e-05, -0.0016475) (6.7303966e-05, -0.0016474904) (6.7109819e-05, -0.0016474616) (6.6919431e-05, -0.0016474139) (6.6734633e-05, -0.0016473478) (6.6557207e-05, -0.0016472638) (6.638886e-05, -0.0016471629) (6.6231213e-05, -0.001647046) (6.6085786e-05, -0.0016469142) (6.5953979e-05, -0.0016467688) (6.5837061e-05, -0.0016466111) (6.5736157e-05, -0.0016464428) (6.5652241e-05, -0.0016462654) (6.5586119e-05, -0.0016460806) (6.5538429e-05, -0.0016458902) (6.5509631e-05, -0.001645696) (6.55e-05, -0.0016455) (6.55e-05, -0.0015845) (6.5509631e-05, -0.001584304) (6.5538429e-05, -0.0015841098) (6.5586119e-05, -0.0015839194) (6.5652241e-05, -0.0015837346) (6.5736157e-05, -0.0015835572) (6.5837061e-05, -0.0015833889) (6.5953979e-05, -0.0015832312) (6.6085786e-05, -0.0015830858) (6.6231213e-05, -0.001582954) (6.638886e-05, -0.0015828371) (6.6557207e-05, -0.0015827362) (6.6734633e-05, -0.0015826522) (6.6919431e-05, -0.0015825861) (6.7109819e-05, -0.0015825384) (6.7303966e-05, -0.0015825096) (6.75e-05, -0.0015825) (8.85e-05, -0.0015825) (8.8696034e-05, -0.0015825096) (8.8890181e-05, -0.0015825384) (8.9080569e-05, -0.0015825861) (8.9265367e-05, -0.0015826522) (8.9442793e-05, -0.0015827362) (8.961114e-05, -0.0015828371) (8.9768787e-05, -0.001582954) (8.9914214e-05, -0.0015830858) (9.0046021e-05, -0.0015832312) (9.0162939e-05, -0.0015833889) (9.0263843e-05, -0.0015835572) (9.0347759e-05, -0.0015837346) (9.0413881e-05, -0.0015839194) (9.0461571e-05, -0.0015841098) (9.0490369e-05, -0.001584304) (9.05e-05, -0.0015845) (9.05e-05, -0.0016455) (9.0490369e-05, -0.001645696) (9.0461571e-05, -0.0016458902) (9.0413881e-05, -0.0016460806) (9.0347759e-05, -0.0016462654) (9.0263843e-05, -0.0016464428) (9.0162939e-05, -0.0016466111) (9.0046021e-05, -0.0016467688) (8.9914214e-05, -0.0016469142) (8.9768787e-05, -0.001647046) (8.961114e-05, -0.0016471629) (8.9442793e-05, -0.0016472638) (8.9265367e-05, -0.0016473478) (8.9080569e-05, -0.0016474139) (8.8890181e-05, -0.0016474616) (8.8696034e-05, -0.0016474904) (8.85e-05, -0.0016475) (6.75e-05, -0.0016475), closed, covered)
  head_b_cj_ch3 [copper] = polyline(z=0, xy: (0.0001115, -0.0016475) (0.00011130397, -0.0016474904) (0.00011110982, -0.0016474616) (0.00011091943, -0.0016474139) (0.00011073463, -0.0016473478) (0.00011055721, -0.0016472638) (0.00011038886, -0.0016471629) (0.00011023121, -0.001647046) (0.00011008579, -0.0016469142) (0.00010995398, -0.0016467688) (0.00010983706, -0.0016466111) (0.00010973616, -0.0016464428) (0.00010965224, -0.0016462654) (0.00010958612, -0.0016460806) (0.00010953843, -0.0016458902) (0.00010950963, -0.001645696) (0.0001095, -0.0016455) (0.0001095, -0.0015845) (0.00010950963, -0.001584304) (0.00010953843, -0.0015841098) (0.00010958612, -0.0015839194) (0.00010965224, -0.0015837346) (0.00010973616, -0.0015835572) (0.00010983706, -0.0015833889) (0.00010995398, -0.0015832312) (0.00011008579, -0.0015830858) (0.00011023121, -0.001582954) (0.00011038886, -0.0015828371) (0.00011055721, -0.0015827362) (0.00011073463, -0.0015826522) (0.00011091943, -0.0015825861) (0.00011110982, -0.0015825384) (0.00011130397, -0.0015825096) (0.0001115, -0.0015825) (0.0001325, -0.0015825) (0.00013269603, -0.0015825096) (0.00013289018, -0.0015825384) (0.00013308057, -0.0015825861) (0.00013326537, -0.0015826522) (0.00013344279, -0.0015827362) (0.00013361114, -0.0015828371) (0.00013376879, -0.001582954) (0.00013391421, -0.0015830858) (0.00013404602, -0.0015832312) (0.00013416294, -0.0015833889) (0.00013426384, -0.0015835572) (0.00013434776, -0.0015837346) (0.00013441388, -0.0015839194) (0.00013446157, -0.0015841098) (0.00013449037, -0.001584304) (0.0001345, -0.0015845) (0.0001345, -0.0016455) (0.00013449037, -0.001645696) (0.00013446157, -0.0016458902) (0.00013441388, -0.0016460806) (0.00013434776, -0.0016462654) (0.00013426384, -0.0016464428) (0.00013416294, -0.0016466111) (0.00013404602, -0.0016467688) (0.00013391421, -0.0016469142) (0.00013376879, -0.001647046) (0.00013361114, -0.0016471629) (0.00013344279, -0.0016472638) (0.00013326537, -0.0016473478) (0.00013308057, -0.0016474139) (0.00013289018, -0.0016474616) (0.00013269603, -0.0016474904) (0.0001325, -0.0016475) (0.0001115, -0.0016475), closed, covered)
  pocket_cj_ch3 = polyline(z=0, xy: (5.15e-05, -0.0016635) (5.1303966e-05, -0.0016634904) (5.1109819e-05, -0.0016634616) (5.0919431e-05, -0.0016634139) (5.0734633e-05, -0.0016633478) (5.0557207e-05, -0.0016632638) (5.038886e-05, -0.0016631629) (5.0231213e-05, -0.001663046) (5.0085786e-05, -0.0016629142) (4.9953979e-05, -0.0016627688) (4.9837061e-05, -0.0016626111) (4.9736157e-05, -0.0016624428) (4.9652241e-05, -0.0016622654) (4.9586119e-05, -0.0016620806) (4.9538429e-05, -0.0016618902) (4.9509631e-05, -0.001661696) (4.95e-05, -0.0016615) (4.95e-05, -0.0015685) (4.9509631e-05, -0.001568304) (4.9538429e-05, -0.0015681098) (4.9586119e-05, -0.0015679194) (4.9652241e-05, -0.0015677346) (4.9736157e-05, -0.0015675572) (4.9837061e-05, -0.0015673889) (4.9953979e-05, -0.0015672312) (5.0085786e-05, -0.0015670858) (5.0231213e-05, -0.001566954) (5.038886e-05, -0.0015668371) (5.0557207e-05, -0.0015667362) (5.0734633e-05, -0.0015666522) (5.0919431e-05, -0.0015665861) (5.1109819e-05, -0.0015665384) (5.1303966e-05, -0.0015665096) (5.15e-05, -0.0015665) (0.0001485, -0.0015665) (0.00014869603, -0.0015665096) (0.00014889018, -0.0015665384) (0.00014908057, -0.0015665861) (0.00014926537, -0.0015666522) (0.00014944279, -0.0015667362) (0.00014961114, -0.0015668371) (0.00014976879, -0.001566954) (0.00014991421, -0.0015670858) (0.00015004602, -0.0015672312) (0.00015016294, -0.0015673889) (0.00015026384, -0.0015675572) (0.00015034776, -0.0015677346) (0.00015041388, -0.0015679194) (0.00015046157, -0.0015681098) (0.00015049037, -0.001568304) (0.0001505, -0.0015685) (0.0001505, -0.0016615) (0.00015049037, -0.001661696) (0.00015046157, -0.0016618902) (0.00015041388, -0.0016620806) (0.00015034776, -0.0016622654) (0.00015026384, -0.0016624428) (0.00015016294, -0.0016626111) (0.00015004602, -0.0016627688) (0.00014991421, -0.0016629142) (0.00014976879, -0.001663046) (0.00014961114, -0.0016631629) (0.00014944279, -0.0016632638) (0.00014926537, -0.0016633478) (0.00014908057, -0.0016634139) (0.00014889018, -0.0016634616) (0.00014869603, -0.0016634904) (0.0001485, -0.0016635) (5.15e-05, -0.0016635), closed, covered)
  endcap_filt_ch3_start = rectangle(corner=(-0.000311, -0.000915, 0), x_size=2.2e-05, y_size=6e-06)
  endcap_res_ch3_start = rectangle(corner=(0.000539, -0.00255834, 0), x_size=2.2e-05, y_size=6e-06)
  endcap_res_a_ch3_start = rectangle(corner=(0.000189, -0.002921, 0), x_size=2.2e-05, y_size=6e-06)
  ground_main_plane [copper] = rectangle(corner=(-0.0017985, -0.003115, 0), x_size=0.003597, y_size=0.0034915)
  main [silicon] = box(corner=(-0.0017985, -0.003115, -0.000525), size=(0.003597, 0.0034915, 0.000525))
  ground_main_plane.subtract(pocket_cj_ch3, endcap_filt_ch3_start, cut_filt_ch3, lead_a_sub_cj_ch3, cut_res_ch3, cut_feed_jf_ch3, cut_res_a_ch3, pocket_cp_ch3, cut_stub_f_ch3, lead_b_sub_cp_ch3, endcap_res_ch3_start, cut_stub_p_ch3, tap_cut_jr_ch3, pocket_LPPout, cut_stub_r_ch3, pocket_LPPin, cut_feed_out, tap_cut_jf_ch3, lead_a_sub_cp_ch3, cut_feed_in, tap_cut_n0_ch3, lead_b_sub_cj_ch3, endcap_res_a_ch3_start)
boundaries and excitations:
  ThinCond1: ThinConductor Objects=[lead_a_cp_ch3, lead_b_cp_ch3, trace_stub_p_ch3, trace_feed_jf_ch3, lead_a_cj_ch3, lead_b_cj_ch3, trace_stub_f_ch3, trace_stub_r_ch3, trace_res_a_ch3, trace_filt_ch3, trace_res_ch3, trace_feed_in, trace_feed_out, launch_pad_LPPin, launch_pad_LPPout, tap_trace_n0_ch3, plate_cp_ch3, frame_cp_ch3, tap_trace_jf_ch3, tap_trace_jr_ch3, head_a_cj_ch3, head_b_cj_ch3, ground_main_plane] Material=pec Thickness=200nm
  frame_cp_ch3: SignalNet Objects=[lead_a_cp_ch3, trace_feed_jf_ch3, lead_a_cj_ch3, trace_stub_f_ch3, trace_filt_ch3, frame_cp_ch3, tap_trace_jf_ch3, head_a_cj_ch3]
  launch_pad_LPPin: SignalNet Objects=[lead_b_cp_ch3, trace_stub_p_ch3, trace_feed_in, trace_feed_out, launch_pad_LPPin, launch_pad_LPPout, tap_trace_n0_ch3, plate_cp_ch3]
  head_b_cj_ch3: SignalNet Objects=[lead_b_cj_ch3, trace_stub_r_ch3, trace_res_a_ch3, trace_res_ch3, tap_trace_jr_ch3, head_b_cj_ch3]
  g_wb: SignalNet Objects=[g_wb, g_wb_1..g_wb_17, ground_main_plane]
setups:
  Setup: Matrix AdaptiveFreq=6.7GHz Cap{MaxPass=15 MinPass=2 MinConvPass=2 PerError=0.3 PerRefine=30 AutoIncreaseSolutionOrder SolutionOrder=Normal Solver_Type=Iterative}
source amplitudes:
  frame_cp_ch3: Cap 1V 0deg
  g_wb, head_b_cj_ch3, launch_pad_LPPin: Cap 0V 0deg

design q3d6_full_2002_q3d (Q3D Extractor, model units mm)
options: SParamCalcMethod=EqTransLine Calculate_Lossy_Dielectrics
geometry:
  lead_a_cp_ch3_path = polyline((0, -0.000362999, 0) (0, -0.000415, 0))
  lead_a_cp_ch3 [copper] = polyline((5e-06, -0.000362999, 0) (-5e-06, -0.000362999, 0))
  lead_a_cp_ch3.sweep_along_path(lead_a_cp_ch3_path)
  lead_a_sub_cp_ch3_path = polyline((0, -0.000362999, 0) (0, -0.000415, 0))
  lead_a_sub_cp_ch3 = polyline((1.1e-05, -0.000362999, 0) (-1.1e-05, -0.000362999, 0))
  lead_a_sub_cp_ch3.sweep_along_path(lead_a_sub_cp_ch3_path)
  lead_b_cp_ch3_path = polyline((0, -0.000262001, 0) (0, -0.00015, 0))
  lead_b_cp_ch3 [copper] = polyline((-5e-06, -0.000262001, 0) (5e-06, -0.000262001, 0))
  lead_b_cp_ch3.sweep_along_path(lead_b_cp_ch3_path)
  lead_b_sub_cp_ch3_path = polyline((0, -0.000262001, 0) (0, -0.00015, 0))
  lead_b_sub_cp_ch3 = polyline((-1.1e-05, -0.000262001, 0) (1.1e-05, -0.000262001, 0))
  lead_b_sub_cp_ch3.sweep_along_path(lead_b_sub_cp_ch3_path)
  trace_stub_p_ch3_path = polyline((0, -0.0001, 0) (0, -0.00015, 0))
  trace_stub_p_ch3 [copper] = polyline((5e-06, -0.0001, 0) (-5e-06, -0.0001, 0))
  trace_stub_p_ch3.sweep_along_path(trace_stub_p_ch3_path)
  cut_stub_p_ch3_path = polyline((0, -0.0001, 0) (0, -0.00015, 0))
  cut_stub_p_ch3 = polyline((1.1e-05, -0.0001, 0) (-1.1e-05, -0.0001, 0))
  cut_stub_p_ch3.sweep_along_path(cut_stub_p_ch3_path)
  trace_feed_jf_ch3_path = polyline((0, -0.000415, 0) (0, -0.001465, 0))
  trace_feed_jf_ch3 [copper] = polyline((5e-06, -0.000415, 0) (-5e-06, -0.000415, 0))
  trace_feed_jf_ch3.sweep_along_path(trace_feed_jf_ch3_path)
  cut_feed_jf_ch3_path = polyline((0, -0.000415, 0) (0, -0.001465, 0))
  cut_feed_jf_ch3 = polyline((1.1e-05, -0.000415, 0) (-1.1e-05, -0.000415, 0))
  cut_feed_jf_ch3.sweep_along_path(cut_feed_jf_ch3_path)
  lead_a_cj_ch3_path = polyline((6.5501e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  lead_a_cj_ch3 [copper] = polyline((6.5501e-05, -0.00162, 0) (6.5501e-05, -0.00161, 0))
  lead_a_cj_ch3.sweep_along_path(lead_a_cj_ch3_path)
  lead_a_sub_cj_ch3_path = polyline((6.5501e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  lead_a_sub_cj_ch3 = polyline((6.5501e-05, -0.001626, 0) (6.5501e-05, -0.001604, 0))
  lead_a_sub_cj_ch3.sweep_along_path(lead_a_sub_cj_ch3_path)
  lead_b_cj_ch3_path = polyline((0.000134499, -0.001615, 0) (0.0001445, -0.001615, 0))
  lead_b_cj_ch3 [copper] = polyline((0.000134499, -0.00161, 0) (0.000134499, -0.00162, 0))
  lead_b_cj_ch3.sweep_along_path(lead_b_cj_ch3_path)
  lead_b_sub_cj_ch3_path = polyline((0.000134499, -0.001615, 0) (0.0001445, -0.001615, 0))
  lead_b_sub_cj_ch3 = polyline((0.000134499, -0.001604, 0) (0.000134499, -0.001626, 0))
  lead_b_sub_cj_ch3.sweep_along_path(lead_b_sub_cj_ch3_path)
  trace_stub_f_ch3_path = polyline((3.55e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  trace_stub_f_ch3 [copper] = polyline((3.55e-05, -0.00161, 0) (3.55e-05, -0.00162, 0))
  trace_stub_f_ch3.sweep_along_path(trace_stub_f_ch3_path)
  cut_stub_f_ch3_path = polyline((3.55e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  cut_stub_f_ch3 = polyline((3.55e-05, -0.001604, 0) (3.55e-05, -0.001626, 0))
  cut_stub_f_ch3.sweep_along_path(cut_stub_f_ch3_path)
  trace_stub_r_ch3_path = polyline((0.0001645, -0.001615, 0) (0.0001445, -0.001615, 0))
  trace_stub_r_ch3 [copper] = polyline((0.0001645, -0.00162, 0) (0.0001645, -0.00161, 0))
  trace_stub_r_ch3.sweep_along_path(trace_stub_r_ch3_path)
  cut_stub_r_ch3_path = polyline((0.0001645, -0.001615, 0) (0.0001445, -0.001615, 0))
  cut_stub_r_ch3 = polyline((0.0001645, -0.001626, 0) (0.0001645, -0.001604, 0))
  cut_stub_r_ch3.sweep_along_path(cut_stub_r_ch3_path)
  trace_res_a_ch3_path = polyline((0.0002, -0.002915, 0) (0.0002, -0.001765, 0))
  trace_res_a_ch3 [copper] = polyline((0.000195, -0.002915, 0) (0.000205, -0.002915, 0))
  trace_res_a_ch3.sweep_along_path(trace_res_a_ch3_path)
  cut_res_a_ch3_path = polyline((0.0002, -0.002915, 0) (0.0002, -0.001765, 0))
  cut_res_a_ch3 = polyline((0.000189, -0.002915, 0) (0.000211, -0.002915, 0))
  cut_res_a_ch3.sweep_along_path(cut_res_a_ch3_path)
  trace_filt_ch3_path = polyline(z=0, xy: (-0.0003, -0.000915) (-0.0003, -0.0022822498) (0, -0.0022822498) (0, -0.001765))
  trace_filt_ch3_path.fillet(Vertices=trace_filt_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  trace_filt_ch3 [copper] = polyline((-0.000295, -0.000915, 0) (-0.000305, -0.000915, 0))
  trace_filt_ch3.sweep_along_path(trace_filt_ch3_path)
  cut_filt_ch3_path = polyline(z=0, xy: (-0.0003, -0.000915) (-0.0003, -0.0022822498) (0, -0.0022822498) (0, -0.001765))
  cut_filt_ch3_path.fillet(Vertices=cut_filt_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  cut_filt_ch3 = polyline((-0.000289, -0.000915, 0) (-0.000311, -0.000915, 0))
  cut_filt_ch3.sweep_along_path(cut_filt_ch3_path)
  trace_res_ch3_path = polyline(z=0, xy: (0.00055, -0.00255234) (0.00055, -0.000665) (0.0002, -0.000665) (0.0002, -0.001465))
  trace_res_ch3_path.fillet(Vertices=trace_res_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  trace_res_ch3 [copper] = polyline((0.000545, -0.00255234, 0) (0.000555, -0.00255234, 0))
  trace_res_ch3.sweep_along_path(trace_res_ch3_path)
  cut_res_ch3_path = polyline(z=0, xy: (0.00055, -0.00255234) (0.00055, -0.000665) (0.0002, -0.000665) (0.0002, -0.001465))
  cut_res_ch3_path.fillet(Vertices=cut_res_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  cut_res_ch3 = polyline((0.000539, -0.00255234, 0) (0.000561, -0.00255234, 0))
  cut_res_ch3.sweep_along_path(cut_res_ch3_path)
  trace_feed_in_path = polyline((-0.00117, 0, 0) (-0.00015, 0, 0))
  trace_feed_in [copper] = polyline((-0.00117, 5e-06, 0) (-0.00117, -5e-06, 0))
  trace_feed_in.sweep_along_path(trace_feed_in_path)
  cut_feed_in_path = polyline((-0.00117, 0, 0) (-0.00015, 0, 0))
  cut_feed_in = polyline((-0.00117, 1.1e-05, 0) (-0.00117, -1.1e-05, 0))
  cut_feed_in.sweep_along_path(cut_feed_in_path)
  trace_feed_out_path = polyline((0.00015, 0, 0) (0.00117, 0, 0))
  trace_feed_out [copper] = polyline((0.00015, 5e-06, 0) (0.00015, -5e-06, 0))
  trace_feed_out.sweep_along_path(trace_feed_out_path)
  cut_feed_out_path = polyline((0.00015, 0, 0) (0.00117, 0, 0))
  cut_feed_out = polyline((0.00015, 1.1e-05, 0) (0.00015, -1.1e-05, 0))
  cut_feed_out.sweep_along_path(cut_feed_out_path)
  g_wb [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-5.5e-05 YPadPos=-0.000765 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_1 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-5.5e-05 YPadPos=-0.001115 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_2 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000255 YPadPos=-0.0025316667 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_3 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000255 YPadPos=-0.0021483333 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_4 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0012568124 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_5 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0015986249 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_6 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0019404373 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_7 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=5.5e-05 YPadPos=-0.0020236249 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_8 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.002174872 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_9 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001797404 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_10 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001419936 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_11 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001042468 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_12 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000145 YPadPos=-0.00093166667 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_13 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000145 YPadPos=-0.0011983333 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_14 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00083 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_15 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00049 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_16 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00049 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_17 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00083 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  launch_pad_LPPin [copper] = polyline(z=0, xy: (-0.0012, 5e-06) (-0.001322, 0.0001) (-0.001522, 0.0001) (-0.001522, -0.0001) (-0.001322, -0.0001) (-0.0012, -5e-06) (-0.00117, -5e-06) (-0.00117, 5e-06) (-0.0012, 5e-06), closed, covered)
  pocket_LPPin = polyline(z=0, xy: (-0.0012, 1.1e-05) (-0.001322, 0.0001765) (-0.0015985, 0.0001765) (-0.0015985, -0.0001765) (-0.001322, -0.0001765) (-0.0012, -1.1e-05) (-0.00117, -1.1e-05) (-0.00117, 1.1e-05) (-0.0012, 1.1e-05), closed, covered)
  launch_pad_LPPout [copper] = polyline(z=0, xy: (0.0012, -5e-06) (0.001322, -0.0001) (0.001522, -0.0001) (0.001522, 0.0001) (0.001322, 0.0001) (0.0012, 5e-06) (0.00117, 5e-06) (0.00117, -5e-06) (0.0012, -5e-06), closed, covered)
  pocket_LPPout = polyline(z=0, xy: (0.0012, -1.1e-05) (0.001322, -0.0001765) (0.0015985, -0.0001765) (0.0015985, 0.0001765) (0.001322, 0.0001765) (0.0012, 1.1e-05) (0.00117, 1.1e-05) (0.00117, -1.1e-05) (0.0012, -1.1e-05), closed, covered)
  tap_trace_n0_ch3 [copper] = polyline(z=0, xy: (-5e-06, -0.0001) (-5e-06, -5e-06) (-0.00015, -5e-06) (-0.00015, 5e-06) (0.00015, 5e-06) (0.00015, -5e-06) (5e-06, -5e-06) (5e-06, -0.0001) (-5e-06, -0.0001), closed, covered)
  tap_cut_n0_ch3 = polyline(z=0, xy: (-1.1e-05, -0.0001) (-1.1e-05, -1.1e-05) (-0.00015, -1.1e-05) (-0.00015, 1.1e-05) (0.00015, 1.1e-05) (0.00015, -1.1e-05) (1.1e-05, -1.1e-05) (1.1e-05, -0.0001) (-1.1e-05, -0.0001), closed, covered)
  plate_cp_ch3 [copper] = polyline(z=0, xy: (8.25e-05, -0.000295) (8.2461478e-05, -0.00029578414) (8.2346282e-05, -0.00029656072) (8.2155523e-05, -0.00029732228) (8.1891036e-05, -0.00029806147) (8.155537e-05, -0.00029877117) (8.1151757e-05, -0.00029944456) (8.0684084e-05, -0.00030007515) (8.0156854e-05, -0.00030065685) (7.9575146e-05, -0.00030118408) (7.8944562e-05, -0.00030165176) (7.8271174e-05, -0.00030205537) (7.7561467e-05, -0.00030239104) (7.6822277e-05, -0.00030265552) (7.6060723e-05, -0.00030284628) (7.5284137e-05, -0.00030296148) (7.45e-05, -0.000303) (-7.45e-05, -0.000303) (-7.5284137e-05, -0.00030296148) (-7.6060723e-05, -0.00030284628) (-7.6822277e-05, -0.00030265552) (-7.7561467e-05, -0.00030239104) (-7.8271174e-05, -0.00030205537) (-7.8944562e-05, -0.00030165176) (-7.9575146e-05, -0.00030118408) (-8.0156854e-05, -0.00030065685) (-8.0684084e-05, -0.00030007515) (-8.1151757e-05, -0.00029944456) (-8.155537e-05, -0.00029877117) (-8.1891036e-05, -0.00029806147) (-8.2155523e-05, -0.00029732228) (-8.2346282e-05, -0.00029656072) (-8.2461478e-05, -0.00029578414) (-8.25e-05, -0.000295) (-8.25e-05, -0.00027) (-8.2461478e-05, -0.00026921586) (-8.2346282e-05, -0.00026843928) (-8.2155523e-05, -0.00026767772) (-8.1891036e-05, -0.00026693853) (-8.155537e-05, -0.00026622883) (-8.1151757e-05, -0.00026555544) (-8.0684084e-05, -0.00026492485) (-8.0156854e-05, -0.00026434315) (-7.9575146e-05, -0.00026381592) (-7.8944562e-05, -0.00026334824) (-7.8271174e-05, -0.00026294463) (-7.7561467e-05, -0.00026260896) (-7.6822277e-05, -0.00026234448) (-7.6060723e-05, -0.00026215372) (-7.5284137e-05, -0.00026203852) (-7.45e-05, -0.000262) (7.45e-05, -0.000262) (7.5284137e-05, -0.00026203852) (7.6060723e-05, -0.00026215372) (7.6822277e-05, -0.00026234448) (7.7561467e-05, -0.00026260896) (7.8271174e-05, -0.00026294463) (7.8944562e-05, -0.00026334824) (7.9575146e-05, -0.00026381592) (8.0156854e-05, -0.00026434315) (8.0684084e-05, -0.00026492485) (8.1151757e-05, -0.00026555544) (8.155537e-05, -0.00026622883) (8.1891036e-05, -0.00026693853) (8.2155523e-05, -0.00026767772) (8.2346282e-05, -0.00026843928) (8.2461478e-05, -0.00026921586) (8.25e-05, -0.00027) (8.25e-05, -0.000295), closed, covered)
  frame_cp_ch3 [copper] = polyline(z=0, xy: (8.25e-05, -0.000311) (8.3284137e-05, -0.00031096148) (8.4060723e-05, -0.00031084628) (8.4822277e-05, -0.00031065552) (8.5561467e-05, -0.00031039104) (8.6271174e-05, -0.00031005537) (8.6944562e-05, -0.00030965176) (8.7575146e-05, -0.00030918408) (8.8156854e-05, -0.00030865685) (8.8684084e-05, -0.00030807515) (8.9151757e-05, -0.00030744456) (8.955537e-05, -0.00030677117) (8.9891036e-05, -0.00030606147) (9.0155523e-05, -0.00030532228) (9.0346282e-05, -0.00030456072) (9.0461478e-05, -0.00030378414) (9.05e-05, -0.000303) (9.05e-05, -0.000262) (9.0461478e-05, -0.00026121586) (9.0346282e-05, -0.00026043928) (9.0155523e-05, -0.00025967772) (8.9891036e-05, -0.00025893853) (8.955537e-05, -0.00025822883) (8.9151757e-05, -0.00025755544) (8.8684084e-05, -0.00025692485) (8.8156854e-05, -0.00025634315) (8.7575146e-05, -0.00025581592) (8.6944562e-05, -0.00025534824) (8.6271174e-05, -0.00025494463) (8.5561467e-05, -0.00025460896) (8.4822277e-05, -0.00025434448) (8.4060723e-05, -0.00025415372) (8.3284137e-05, -0.00025403852) (8.25e-05, -0.000254) (1.909818e-05, -0.000254) (1.8901939e-05, -0.00025399518) (1.8412015e-05, -0.00025397111) (1.80216e-05, -0.00025393266) (1.7633541e-05, -0.0002538751) (1.7248774e-05, -0.00025379856) (1.6868226e-05, -0.00025370324) (1.6492814e-05, -0.00025358936) (1.6123441e-05, -0.0002534572) (1.5760999e-05, -0.00025330707) (1.540636e-05, -0.00025313934) (1.5060378e-05, -0.00025295441) (1.4723887e-05, -0.00025275272) (1.4397697e-05, -0.00025253477) (1.4082595e-05, -0.00025230107) (1.3779339e-05, -0.0002520522) (1.348866e-05, -0.00025178874) (1.3211259e-05, -0.00025151134) (1.2947803e-05, -0.00025122066) (1.2698928e-05, -0.0002509174) (1.2465232e-05, -0.0002506023) (1.2247279e-05, -0.00025027611) (1.2045594e-05, -0.00024993962) (1.1860663e-05, -0.00024959364) (1.1692931e-05, -0.000249239) (1.1542802e-05, -0.00024887656) (1.1410639e-05, -0.00024850719) (1.1296759e-05, -0.00024813177) (1.1201436e-05, -0.00024775123) (1.1124902e-05, -0.00024736646) (1.1067338e-05, -0.0002469784) (1.1028886e-05, -0.00024658799) (1.1004817e-05, -0.00024609806) (1.1e-05, -0.00024590182) (1.1e-05, -0.00019809818) (1.1004817e-05, -0.00019790194) (1.1028886e-05, -0.00019741201) (1.1067338e-05, -0.0001970216) (1.1124902e-05, -0.00019663354) (1.1201436e-05, -0.00019624877) (1.1296759e-05, -0.00019586823) (1.1410639e-05, -0.00019549281) (1.1542802e-05, -0.00019512344) (1.1692931e-05, -0.000194761) (1.1860663e-05, -0.00019440636) (1.2045594e-05, -0.00019406038) (1.2247279e-05, -0.00019372389) (1.2465232e-05, -0.0001933977) (1.2698928e-05, -0.00019308259) (1.2947803e-05, -0.00019277934) (1.3211259e-05, -0.00019248866) (1.348866e-05, -0.00019221126) (1.3779339e-05, -0.0001919478) (1.4082595e-05, -0.00019169893) (1.4397697e-05, -0.00019146523) (1.4723887e-05, -0.00019124728) (1.5060378e-05, -0.00019104559) (1.540636e-05, -0.00019086066) (1.5760999e-05, -0.00019069293) (1.6123441e-05, -0.0001905428) (1.6492814e-05, -0.00019041064) (1.6868226e-05, -0.00019029676) (1.7248774e-05, -0.00019020144) (1.7633541e-05, -0.0001901249) (1.80216e-05, -0.00019006734) (1.8412015e-05, -0.00019002889) (1.8901939e-05, -0.00019000482) (1.909818e-05, -0.00019) (0.00013940182, -0.00019) (0.00013959806, -0.00019000482) (0.00014008798, -0.00019002889) (0.0001404784, -0.00019006734) (0.00014086646, -0.0001901249) (0.00014125123, -0.00019020144) (0.00014163177, -0.00019029676) (0.00014200719, -0.00019041064) (0.00014237656, -0.0001905428) (0.000142739, -0.00019069293) (0.00014309364, -0.00019086066) (0.00014343962, -0.00019104559) (0.00014377611, -0.00019124728) (0.0001441023, -0.00019146523) (0.0001444174, -0.00019169893) (0.00014472066, -0.0001919478) (0.00014501134, -0.00019221126) (0.00014528874, -0.00019248866) (0.0001455522, -0.00019277934) (0.00014580107, -0.00019308259) (0.00014603477, -0.0001933977) (0.00014625272, -0.00019372389) (0.00014645441, -0.00019406038) (0.00014663934, -0.00019440636) (0.00014680707, -0.000194761) (0.0001469572, -0.00019512344) (0.00014708936, -0.00019549281) (0.00014720324, -0.00019586823) (0.00014729856, -0.00019624877) (0.0001473751, -0.00019663354) (0.00014743266, -0.0001970216) (0.00014747111, -0.00019741201) (0.00014749518, -0.00019790194) (0.0001475, -0.00019809818) (0.0001475, -0.00035490182) (0.00014749518, -0.00035509806) (0.00014747111, -0.00035558799) (0.00014743266, -0.0003559784) (0.0001473751, -0.00035636646) (0.00014729856, -0.00035675123) (0.00014720324, -0.00035713177) (0.00014708936, -0.00035750719) (0.0001469572, -0.00035787656) (0.00014680707, -0.000358239) (0.00014663934, -0.00035859364) (0.00014645441, -0.00035893962) (0.00014625272, -0.00035927611) (0.00014603477, -0.0003596023) (0.00014580107, -0.00035991741) (0.0001455522, -0.00036022066) (0.00014528874, -0.00036051134) (0.00014501134, -0.00036078874) (0.00014472066, -0.0003610522) (0.0001444174, -0.00036130107) (0.0001441023, -0.00036153477) (0.00014377611, -0.00036175272) (0.00014343962, -0.00036195441) (0.00014309364, -0.00036213934) (0.000142739, -0.00036230707) (0.00014237656, -0.0003624572) (0.00014200719, -0.00036258936) (0.00014163177, -0.00036270324) (0.00014125123, -0.00036279856) (0.00014086646, -0.0003628751) (0.0001404784, -0.00036293266) (0.00014008798, -0.00036297111) (0.00013959806, -0.00036299518) (0.00013940182, -0.000363) (-0.00013940182, -0.000363) (-0.00013959806, -0.00036299518) (-0.00014008798, -0.00036297111) (-0.0001404784, -0.00036293266) (-0.00014086646, -0.0003628751) (-0.00014125123, -0.00036279856) (-0.00014163177, -0.00036270324) (-0.00014200719, -0.00036258936) (-0.00014237656, -0.0003624572) (-0.000142739, -0.00036230707) (-0.00014309364, -0.00036213934) (-0.00014343962, -0.00036195441) (-0.00014377611, -0.00036175272) (-0.0001441023, -0.00036153477) (-0.0001444174, -0.00036130107) (-0.00014472066, -0.0003610522) (-0.00014501134, -0.00036078874) (-0.00014528874, -0.00036051134) (-0.0001455522, -0.00036022066) (-0.00014580107, -0.00035991741) (-0.00014603477, -0.0003596023) (-0.00014625272, -0.00035927611) (-0.00014645441, -0.00035893962) (-0.00014663934, -0.00035859364) (-0.00014680707, -0.000358239) (-0.0001469572, -0.00035787656) (-0.00014708936, -0.00035750719) (-0.00014720324, -0.00035713177) (-0.00014729856, -0.00035675123) (-0.0001473751, -0.00035636646) (-0.00014743266, -0.0003559784) (-0.00014747111, -0.00035558799) (-0.00014749518, -0.00035509806) (-0.0001475, -0.00035490182) (-0.0001475, -0.00019809818) (-0.00014749518, -0.00019790194) (-0.00014747111, -0.00019741201) (-0.00014743266, -0.0001970216) (-0.0001473751, -0.00019663354) (-0.00014729856, -0.00019624877) (-0.00014720324, -0.00019586823) (-0.00014708936, -0.00019549281) (-0.0001469572, -0.00019512344) (-0.00014680707, -0.000194761) (-0.00014663934, -0.00019440636) (-0.00014645441, -0.00019406038) (-0.00014625272, -0.00019372389) (-0.00014603477, -0.0001933977) (-0.00014580107, -0.00019308259) (-0.0001455522, -0.00019277934) (-0.00014528874, -0.00019248866) (-0.00014501134, -0.00019221126) (-0.00014472066, -0.0001919478) (-0.0001444174, -0.00019169893) (-0.0001441023, -0.00019146523) (-0.00014377611, -0.00019124728) (-0.00014343962, -0.00019104559) (-0.00014309364, -0.00019086066) (-0.000142739, -0.00019069293) (-0.00014237656, -0.0001905428) (-0.00014200719, -0.00019041064) (-0.00014163177, -0.00019029676) (-0.00014125123, -0.00019020144) (-0.00014086646, -0.0001901249) (-0.0001404784, -0.00019006734) (-0.00014008798, -0.00019002889) (-0.00013959806, -0.00019000482) (-0.00013940182, -0.00019) (-1.909818e-05, -0.00019) (-1.8901939e-05, -0.00019000482) (-1.8412015e-05, -0.00019002889) (-1.80216e-05, -0.00019006734) (-1.7633541e-05, -0.0001901249) (-1.7248774e-05, -0.00019020144) (-1.6868226e-05, -0.00019029676) (-1.6492814e-05, -0.00019041064) (-1.6123441e-05, -0.0001905428) (-1.5760999e-05, -0.00019069293) (-1.540636e-05, -0.00019086066) (-1.5060378e-05, -0.00019104559) (-1.4723887e-05, -0.00019124728) (-1.4397697e-05, -0.00019146523) (-1.4082595e-05, -0.00019169893) (-1.3779339e-05, -0.0001919478) (-1.348866e-05, -0.00019221126) (-1.3211259e-05, -0.00019248866) (-1.2947803e-05, -0.00019277934) (-1.2698928e-05, -0.00019308259) (-1.2465232e-05, -0.0001933977) (-1.2247279e-05, -0.00019372389) (-1.2045594e-05, -0.00019406038) (-1.1860663e-05, -0.00019440636) (-1.1692931e-05, -0.000194761) (-1.1542802e-05, -0.00019512344) (-1.1410639e-05, -0.00019549281) (-1.1296759e-05, -0.00019586823) (-1.1201436e-05, -0.00019624877) (-1.1124902e-05, -0.00019663354) (-1.1067338e-05, -0.0001970216) (-1.1028886e-05, -0.00019741201) (-1.1004817e-05, -0.00019790194) (-1.1e-05, -0.00019809818) (-1.1e-05, -0.00024590182) (-1.1004817e-05, -0.00024609806) (-1.1028886e-05, -0.00024658799) (-1.1067338e-05, -0.0002469784) (-1.1124902e-05, -0.00024736646) (-1.1201436e-05, -0.00024775123) (-1.1296759e-05, -0.00024813177) (-1.1410639e-05, -0.00024850719) (-1.1542802e-05, -0.00024887656) (-1.1692931e-05, -0.000249239) (-1.1860663e-05, -0.00024959364) (-1.2045594e-05, -0.00024993962) (-1.2247279e-05, -0.00025027611) (-1.2465232e-05, -0.0002506023) (-1.2698928e-05, -0.0002509174) (-1.2947803e-05, -0.00025122066) (-1.3211259e-05, -0.00025151134) (-1.348866e-05, -0.00025178874) (-1.3779339e-05, -0.0002520522) (-1.4082595e-05, -0.00025230107) (-1.4397697e-05, -0.00025253477) (-1.4723887e-05, -0.00025275272) (-1.5060378e-05, -0.00025295441) (-1.540636e-05, -0.00025313934) (-1.5760999e-05, -0.00025330707) (-1.6123441e-05, -0.0002534572) (-1.6492814e-05, -0.00025358936) (-1.6868226e-05, -0.00025370324)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, closed, covered)
  pocket_cp_ch3 = polyline(z=0, xy: (0.0001475, -0.000375) (-0.0001475, -0.000375) (-0.00014867621, -0.00037494222) (-0.00014984108, -0.00037476942) (-0.00015098342, -0.00037448328) (-0.0001520922, -0.00037408655) (-0.00015315676, -0.00037358305) (-0.00015416684, -0.00037297763) (-0.00015511272, -0.00037227612) (-0.00015598528, -0.00037148528) (-0.00015677613, -0.00037061272) (-0.00015747764, -0.00036966684) (-0.00015808305, -0.00036865676) (-0.00015858655, -0.0003675922) (-0.00015898328, -0.00036648342) (-0.00015926942, -0.00036534108) (-0.00015944222, -0.00036417621) (-0.0001595, -0.000363) (-0.0001595, -0.00019) (-0.00015944222, -0.00018882379) (-0.00015926942, -0.00018765892) (-0.00015898328, -0.00018651658) (-0.00015858655, -0.0001854078) (-0.00015808305, -0.00018434324) (-0.00015747764, -0.00018333316) (-0.00015677613, -0.00018238728) (-0.00015598528, -0.00018151472) (-0.00015511272, -0.00018072388) (-0.00015416684, -0.00018002237) (-0.00015315676, -0.00017941694) (-0.0001520922, -0.00017891345) (-0.00015098342, -0.00017851672) (-0.00014984108, -0.00017823058) (-0.00014867621, -0.00017805778) (-0.0001475, -0.000178) (0.0001475, -0.000178) (0.00014867621, -0.00017805778) (0.00014984108, -0.00017823058) (0.00015098342, -0.00017851672) (0.0001520922, -0.00017891345) (0.00015315676, -0.00017941694) (0.00015416684, -0.00018002237) (0.00015511272, -0.00018072388) (0.00015598528, -0.00018151472) (0.00015677613, -0.00018238728) (0.00015747764, -0.00018333316) (0.00015808305, -0.00018434324) (0.00015858655, -0.0001854078) (0.00015898328, -0.00018651658) (0.00015926942, -0.00018765892) (0.00015944222, -0.00018882379) (0.0001595, -0.00019) (0.0001595, -0.000363) (0.00015944222, -0.00036417621) (0.00015926942, -0.00036534108) (0.00015898328, -0.00036648342) (0.00015858655, -0.0003675922) (0.00015808305, -0.00036865676) (0.00015747764, -0.00036966684) (0.00015677613, -0.00037061272) (0.00015598528, -0.00037148528) (0.00015511272, -0.00037227612) (0.00015416684, -0.00037297763) (0.00015315676, -0.00037358305) (0.0001520922, -0.00037408655) (0.00015098342, -0.00037448328) (0.00014984108, -0.00037476942) (0.00014867621, -0.00037494222) (0.0001475, -0.000375), closed, covered)
  tap_trace_jf_ch3 [copper] = polyline(z=0, xy: (5e-06, -0.001465) (5e-06, -0.00161) (3.55e-05, -0.00161) (3.55e-05, -0.00162) (5e-06, -0.00162) (5e-06, -0.001765) (-5e-06, -0.001765) (-5e-06, -0.001465) (5e-06, -0.001465), closed, covered)
  tap_cut_jf_ch3 = polyline(z=0, xy: (1.1e-05, -0.001465) (1.1e-05, -0.001604) (3.55e-05, -0.001604) (3.55e-05, -0.001626) (1.1e-05, -0.001626) (1.1e-05, -0.001765) (-1.1e-05, -0.001765) (-1.1e-05, -0.001465) (1.1e-05, -0.001465), closed, covered)
  tap_trace_jr_ch3 [copper] = polyline(z=0, xy: (0.0001645, -0.00161) (0.000195, -0.00161) (0.000195, -0.001465) (0.000205, -0.001465) (0.000205, -0.001765) (0.000195, -0.001765) (0.000195, -0.00162) (0.0001645, -0.00162) (0.0001645, -0.00161), closed, covered)
  tap_cut_jr_ch3 = polyline(z=0, xy: (0.0001645, -0.001604) (0.000189, -0.001604) (0.000189, -0.001465) (0.000211, -0.001465) (0.000211, -0.001765) (0.000189, -0.001765) (0.000189, -0.001626) (0.0001645, -0.001626) (0.0001645, -0.001604), closed, covered)
  head_a_cj_ch3 [copper] = polyline(z=0, xy: (6.75e-05, -0.0016475) (6.7303966e-05, -0.0016474904) (6.7109819e-05, -0.0016474616) (6.6919431e-05, -0.0016474139) (6.6734633e-05, -0.0016473478) (6.6557207e-05, -0.0016472638) (6.638886e-05, -0.0016471629) (6.6231213e-05, -0.001647046) (6.6085786e-05, -0.0016469142) (6.5953979e-05, -0.0016467688) (6.5837061e-05, -0.0016466111) (6.5736157e-05, -0.0016464428) (6.5652241e-05, -0.0016462654) (6.5586119e-05, -0.0016460806) (6.5538429e-05, -0.0016458902) (6.5509631e-05, -0.001645696) (6.55e-05, -0.0016455) (6.55e-05, -0.0015845) (6.5509631e-05, -0.001584304) (6.5538429e-05, -0.0015841098) (6.5586119e-05, -0.0015839194) (6.5652241e-05, -0.0015837346) (6.5736157e-05, -0.0015835572) (6.5837061e-05, -0.0015833889) (6.5953979e-05, -0.0015832312) (6.6085786e-05, -0.0015830858) (6.6231213e-05, -0.001582954) (6.638886e-05, -0.0015828371) (6.6557207e-05, -0.0015827362) (6.6734633e-05, -0.0015826522) (6.6919431e-05, -0.0015825861) (6.7109819e-05, -0.0015825384) (6.7303966e-05, -0.0015825096) (6.75e-05, -0.0015825) (8.85e-05, -0.0015825) (8.8696034e-05, -0.0015825096) (8.8890181e-05, -0.0015825384) (8.9080569e-05, -0.0015825861) (8.9265367e-05, -0.0015826522) (8.9442793e-05, -0.0015827362) (8.961114e-05, -0.0015828371) (8.9768787e-05, -0.001582954) (8.9914214e-05, -0.0015830858) (9.0046021e-05, -0.0015832312) (9.0162939e-05, -0.0015833889) (9.0263843e-05, -0.0015835572) (9.0347759e-05, -0.0015837346) (9.0413881e-05, -0.0015839194) (9.0461571e-05, -0.0015841098) (9.0490369e-05, -0.001584304) (9.05e-05, -0.0015845) (9.05e-05, -0.0016455) (9.0490369e-05, -0.001645696) (9.0461571e-05, -0.0016458902) (9.0413881e-05, -0.0016460806) (9.0347759e-05, -0.0016462654) (9.0263843e-05, -0.0016464428) (9.0162939e-05, -0.0016466111) (9.0046021e-05, -0.0016467688) (8.9914214e-05, -0.0016469142) (8.9768787e-05, -0.001647046) (8.961114e-05, -0.0016471629) (8.9442793e-05, -0.0016472638) (8.9265367e-05, -0.0016473478) (8.9080569e-05, -0.0016474139) (8.8890181e-05, -0.0016474616) (8.8696034e-05, -0.0016474904) (8.85e-05, -0.0016475) (6.75e-05, -0.0016475), closed, covered)
  head_b_cj_ch3 [copper] = polyline(z=0, xy: (0.0001115, -0.0016475) (0.00011130397, -0.0016474904) (0.00011110982, -0.0016474616) (0.00011091943, -0.0016474139) (0.00011073463, -0.0016473478) (0.00011055721, -0.0016472638) (0.00011038886, -0.0016471629) (0.00011023121, -0.001647046) (0.00011008579, -0.0016469142) (0.00010995398, -0.0016467688) (0.00010983706, -0.0016466111) (0.00010973616, -0.0016464428) (0.00010965224, -0.0016462654) (0.00010958612, -0.0016460806) (0.00010953843, -0.0016458902) (0.00010950963, -0.001645696) (0.0001095, -0.0016455) (0.0001095, -0.0015845) (0.00010950963, -0.001584304) (0.00010953843, -0.0015841098) (0.00010958612, -0.0015839194) (0.00010965224, -0.0015837346) (0.00010973616, -0.0015835572) (0.00010983706, -0.0015833889) (0.00010995398, -0.0015832312) (0.00011008579, -0.0015830858) (0.00011023121, -0.001582954) (0.00011038886, -0.0015828371) (0.00011055721, -0.0015827362) (0.00011073463, -0.0015826522) (0.00011091943, -0.0015825861) (0.00011110982, -0.0015825384) (0.00011130397, -0.0015825096) (0.0001115, -0.0015825) (0.0001325, -0.0015825) (0.00013269603, -0.0015825096) (0.00013289018, -0.0015825384) (0.00013308057, -0.0015825861) (0.00013326537, -0.0015826522) (0.00013344279, -0.0015827362) (0.00013361114, -0.0015828371) (0.00013376879, -0.001582954) (0.00013391421, -0.0015830858) (0.00013404602, -0.0015832312) (0.00013416294, -0.0015833889) (0.00013426384, -0.0015835572) (0.00013434776, -0.0015837346) (0.00013441388, -0.0015839194) (0.00013446157, -0.0015841098) (0.00013449037, -0.001584304) (0.0001345, -0.0015845) (0.0001345, -0.0016455) (0.00013449037, -0.001645696) (0.00013446157, -0.0016458902) (0.00013441388, -0.0016460806) (0.00013434776, -0.0016462654) (0.00013426384, -0.0016464428) (0.00013416294, -0.0016466111) (0.00013404602, -0.0016467688) (0.00013391421, -0.0016469142) (0.00013376879, -0.001647046) (0.00013361114, -0.0016471629) (0.00013344279, -0.0016472638) (0.00013326537, -0.0016473478) (0.00013308057, -0.0016474139) (0.00013289018, -0.0016474616) (0.00013269603, -0.0016474904) (0.0001325, -0.0016475) (0.0001115, -0.0016475), closed, covered)
  pocket_cj_ch3 = polyline(z=0, xy: (5.15e-05, -0.0016635) (5.1303966e-05, -0.0016634904) (5.1109819e-05, -0.0016634616) (5.0919431e-05, -0.0016634139) (5.0734633e-05, -0.0016633478) (5.0557207e-05, -0.0016632638) (5.038886e-05, -0.0016631629) (5.0231213e-05, -0.001663046) (5.0085786e-05, -0.0016629142) (4.9953979e-05, -0.0016627688) (4.9837061e-05, -0.0016626111) (4.9736157e-05, -0.0016624428) (4.9652241e-05, -0.0016622654) (4.9586119e-05, -0.0016620806) (4.9538429e-05, -0.0016618902) (4.9509631e-05, -0.001661696) (4.95e-05, -0.0016615) (4.95e-05, -0.0015685) (4.9509631e-05, -0.001568304) (4.9538429e-05, -0.0015681098) (4.9586119e-05, -0.0015679194) (4.9652241e-05, -0.0015677346) (4.9736157e-05, -0.0015675572) (4.9837061e-05, -0.0015673889) (4.9953979e-05, -0.0015672312) (5.0085786e-05, -0.0015670858) (5.0231213e-05, -0.001566954) (5.038886e-05, -0.0015668371) (5.0557207e-05, -0.0015667362) (5.0734633e-05, -0.0015666522) (5.0919431e-05, -0.0015665861) (5.1109819e-05, -0.0015665384) (5.1303966e-05, -0.0015665096) (5.15e-05, -0.0015665) (0.0001485, -0.0015665) (0.00014869603, -0.0015665096) (0.00014889018, -0.0015665384) (0.00014908057, -0.0015665861) (0.00014926537, -0.0015666522) (0.00014944279, -0.0015667362) (0.00014961114, -0.0015668371) (0.00014976879, -0.001566954) (0.00014991421, -0.0015670858) (0.00015004602, -0.0015672312) (0.00015016294, -0.0015673889) (0.00015026384, -0.0015675572) (0.00015034776, -0.0015677346) (0.00015041388, -0.0015679194) (0.00015046157, -0.0015681098) (0.00015049037, -0.001568304) (0.0001505, -0.0015685) (0.0001505, -0.0016615) (0.00015049037, -0.001661696) (0.00015046157, -0.0016618902) (0.00015041388, -0.0016620806) (0.00015034776, -0.0016622654) (0.00015026384, -0.0016624428) (0.00015016294, -0.0016626111) (0.00015004602, -0.0016627688) (0.00014991421, -0.0016629142) (0.00014976879, -0.001663046) (0.00014961114, -0.0016631629) (0.00014944279, -0.0016632638) (0.00014926537, -0.0016633478) (0.00014908057, -0.0016634139) (0.00014889018, -0.0016634616) (0.00014869603, -0.0016634904) (0.0001485, -0.0016635) (5.15e-05, -0.0016635), closed, covered)
  endcap_filt_ch3_start = rectangle(corner=(-0.000311, -0.000915, 0), x_size=2.2e-05, y_size=6e-06)
  endcap_res_ch3_start = rectangle(corner=(0.000539, -0.00255834, 0), x_size=2.2e-05, y_size=6e-06)
  endcap_res_a_ch3_start = rectangle(corner=(0.000189, -0.002921, 0), x_size=2.2e-05, y_size=6e-06)
  ground_main_plane [copper] = rectangle(corner=(-0.0017985, -0.003115, 0), x_size=0.003597, y_size=0.0034915)
  main [silicon] = box(corner=(-0.0017985, -0.003115, -0.000525), size=(0.003597, 0.0034915, 0.000525))
  ground_main_plane.subtract(cut_feed_jf_ch3, pocket_LPPin, endcap_res_a_ch3_start, cut_stub_f_ch3, cut_feed_in, tap_cut_jr_ch3, endcap_filt_ch3_start, endcap_res_ch3_start, cut_stub_r_ch3, cut_filt_ch3, tap_cut_n0_ch3, lead_a_sub_cp_ch3, pocket_cj_ch3, tap_cut_jf_ch3, pocket_LPPout, cut_res_ch3, lead_a_sub_cj_ch3, pocket_cp_ch3, cut_stub_p_ch3, cut_feed_out, lead_b_sub_cj_ch3, lead_b_sub_cp_ch3, cut_res_a_ch3)
boundaries and excitations:
  ThinCond1: ThinConductor Objects=[lead_a_cp_ch3, lead_b_cp_ch3, trace_stub_p_ch3, trace_feed_jf_ch3, lead_a_cj_ch3, lead_b_cj_ch3, trace_stub_f_ch3, trace_stub_r_ch3, trace_res_a_ch3, trace_filt_ch3, trace_res_ch3, trace_feed_in, trace_feed_out, launch_pad_LPPin, launch_pad_LPPout, tap_trace_n0_ch3, plate_cp_ch3, frame_cp_ch3, tap_trace_jf_ch3, tap_trace_jr_ch3, head_a_cj_ch3, head_b_cj_ch3, ground_main_plane] Material=pec Thickness=200nm
  frame_cp_ch3: SignalNet Objects=[lead_a_cp_ch3, trace_feed_jf_ch3, lead_a_cj_ch3, trace_stub_f_ch3, trace_filt_ch3, frame_cp_ch3, tap_trace_jf_ch3, head_a_cj_ch3]
  launch_pad_LPPin: SignalNet Objects=[lead_b_cp_ch3, trace_stub_p_ch3, trace_feed_in, trace_feed_out, launch_pad_LPPin, launch_pad_LPPout, tap_trace_n0_ch3, plate_cp_ch3]
  head_b_cj_ch3: SignalNet Objects=[lead_b_cj_ch3, trace_stub_r_ch3, trace_res_a_ch3, trace_res_ch3, tap_trace_jr_ch3, head_b_cj_ch3]
  g_wb: SignalNet Objects=[g_wb, g_wb_1..g_wb_17, ground_main_plane]
setups:
  Setup: Matrix AdaptiveFreq=6.7GHz Cap{MaxPass=15 MinPass=2 MinConvPass=2 PerError=0.3 PerRefine=30 AutoIncreaseSolutionOrder SolutionOrder=Normal Solver_Type=Iterative}
source amplitudes:
  frame_cp_ch3: Cap 1V 0deg
  g_wb, head_b_cj_ch3, launch_pad_LPPin: Cap 0V 0deg

design v6_full_eig_2034_hfss (HFSS, Eigenmode, model units mm)
geometry:
  lead_a_cp_ch3_path = polyline((0, -0.000362999, 0) (0, -0.000415, 0))
  lead_a_cp_ch3 = polyline((5e-06, -0.000362999, 0) (-5e-06, -0.000362999, 0))
  lead_a_cp_ch3.sweep_along_path(lead_a_cp_ch3_path)
  lead_a_sub_cp_ch3_path = polyline((0, -0.000362999, 0) (0, -0.000415, 0))
  lead_a_sub_cp_ch3 = polyline((1.1e-05, -0.000362999, 0) (-1.1e-05, -0.000362999, 0))
  lead_a_sub_cp_ch3.sweep_along_path(lead_a_sub_cp_ch3_path)
  lead_b_cp_ch3_path = polyline((0, -0.000262001, 0) (0, -0.00015, 0))
  lead_b_cp_ch3 = polyline((-5e-06, -0.000262001, 0) (5e-06, -0.000262001, 0))
  lead_b_cp_ch3.sweep_along_path(lead_b_cp_ch3_path)
  lead_b_sub_cp_ch3_path = polyline((0, -0.000262001, 0) (0, -0.00015, 0))
  lead_b_sub_cp_ch3 = polyline((-1.1e-05, -0.000262001, 0) (1.1e-05, -0.000262001, 0))
  lead_b_sub_cp_ch3.sweep_along_path(lead_b_sub_cp_ch3_path)
  trace_stub_p_ch3_path = polyline((0, -0.0001, 0) (0, -0.00015, 0))
  trace_stub_p_ch3 = polyline((5e-06, -0.0001, 0) (-5e-06, -0.0001, 0))
  trace_stub_p_ch3.sweep_along_path(trace_stub_p_ch3_path)
  cut_stub_p_ch3_path = polyline((0, -0.0001, 0) (0, -0.00015, 0))
  cut_stub_p_ch3 = polyline((1.1e-05, -0.0001, 0) (-1.1e-05, -0.0001, 0))
  cut_stub_p_ch3.sweep_along_path(cut_stub_p_ch3_path)
  trace_feed_jf_ch3_path = polyline((0, -0.000415, 0) (0, -0.001465, 0))
  trace_feed_jf_ch3 = polyline((5e-06, -0.000415, 0) (-5e-06, -0.000415, 0))
  trace_feed_jf_ch3.sweep_along_path(trace_feed_jf_ch3_path)
  cut_feed_jf_ch3_path = polyline((0, -0.000415, 0) (0, -0.001465, 0))
  cut_feed_jf_ch3 = polyline((1.1e-05, -0.000415, 0) (-1.1e-05, -0.000415, 0))
  cut_feed_jf_ch3.sweep_along_path(cut_feed_jf_ch3_path)
  lead_a_cj_ch3_path = polyline((6.5501e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  lead_a_cj_ch3 = polyline((6.5501e-05, -0.00162, 0) (6.5501e-05, -0.00161, 0))
  lead_a_cj_ch3.sweep_along_path(lead_a_cj_ch3_path)
  lead_a_sub_cj_ch3_path = polyline((6.5501e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  lead_a_sub_cj_ch3 = polyline((6.5501e-05, -0.001626, 0) (6.5501e-05, -0.001604, 0))
  lead_a_sub_cj_ch3.sweep_along_path(lead_a_sub_cj_ch3_path)
  lead_b_cj_ch3_path = polyline((0.000134499, -0.001615, 0) (0.0001445, -0.001615, 0))
  lead_b_cj_ch3 = polyline((0.000134499, -0.00161, 0) (0.000134499, -0.00162, 0))
  lead_b_cj_ch3.sweep_along_path(lead_b_cj_ch3_path)
  lead_b_sub_cj_ch3_path = polyline((0.000134499, -0.001615, 0) (0.0001445, -0.001615, 0))
  lead_b_sub_cj_ch3 = polyline((0.000134499, -0.001604, 0) (0.000134499, -0.001626, 0))
  lead_b_sub_cj_ch3.sweep_along_path(lead_b_sub_cj_ch3_path)
  trace_stub_f_ch3_path = polyline((3.55e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  trace_stub_f_ch3 = polyline((3.55e-05, -0.00161, 0) (3.55e-05, -0.00162, 0))
  trace_stub_f_ch3.sweep_along_path(trace_stub_f_ch3_path)
  cut_stub_f_ch3_path = polyline((3.55e-05, -0.001615, 0) (5.55e-05, -0.001615, 0))
  cut_stub_f_ch3 = polyline((3.55e-05, -0.001604, 0) (3.55e-05, -0.001626, 0))
  cut_stub_f_ch3.sweep_along_path(cut_stub_f_ch3_path)
  trace_stub_r_ch3_path = polyline((0.0001645, -0.001615, 0) (0.0001445, -0.001615, 0))
  trace_stub_r_ch3 = polyline((0.0001645, -0.00162, 0) (0.0001645, -0.00161, 0))
  trace_stub_r_ch3.sweep_along_path(trace_stub_r_ch3_path)
  cut_stub_r_ch3_path = polyline((0.0001645, -0.001615, 0) (0.0001445, -0.001615, 0))
  cut_stub_r_ch3 = polyline((0.0001645, -0.001626, 0) (0.0001645, -0.001604, 0))
  cut_stub_r_ch3.sweep_along_path(cut_stub_r_ch3_path)
  trace_res_a_ch3_path = polyline((0.0002, -0.002915, 0) (0.0002, -0.001765, 0))
  trace_res_a_ch3 = polyline((0.000195, -0.002915, 0) (0.000205, -0.002915, 0))
  trace_res_a_ch3.sweep_along_path(trace_res_a_ch3_path)
  cut_res_a_ch3_path = polyline((0.0002, -0.002915, 0) (0.0002, -0.001765, 0))
  cut_res_a_ch3 = polyline((0.000189, -0.002915, 0) (0.000211, -0.002915, 0))
  cut_res_a_ch3.sweep_along_path(cut_res_a_ch3_path)
  trace_filt_ch3_path = polyline(z=0, xy: (-0.0003, -0.000915) (-0.0003, -0.0022822498) (0, -0.0022822498) (0, -0.001765))
  trace_filt_ch3_path.fillet(Vertices=trace_filt_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  trace_filt_ch3 = polyline((-0.000295, -0.000915, 0) (-0.000305, -0.000915, 0))
  trace_filt_ch3.sweep_along_path(trace_filt_ch3_path)
  cut_filt_ch3_path = polyline(z=0, xy: (-0.0003, -0.000915) (-0.0003, -0.0022822498) (0, -0.0022822498) (0, -0.001765))
  cut_filt_ch3_path.fillet(Vertices=cut_filt_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  cut_filt_ch3 = polyline((-0.000289, -0.000915, 0) (-0.000311, -0.000915, 0))
  cut_filt_ch3.sweep_along_path(cut_filt_ch3_path)
  trace_res_ch3_path = polyline(z=0, xy: (0.00055, -0.00255234) (0.00055, -0.000665) (0.0002, -0.000665) (0.0002, -0.001465))
  trace_res_ch3_path.fillet(Vertices=trace_res_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  trace_res_ch3 = polyline((0.000545, -0.00255234, 0) (0.000555, -0.00255234, 0))
  trace_res_ch3.sweep_along_path(trace_res_ch3_path)
  cut_res_ch3_path = polyline(z=0, xy: (0.00055, -0.00255234) (0.00055, -0.000665) (0.0002, -0.000665) (0.0002, -0.001465))
  cut_res_ch3_path.fillet(Vertices=cut_res_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  cut_res_ch3 = polyline((0.000539, -0.00255234, 0) (0.000561, -0.00255234, 0))
  cut_res_ch3.sweep_along_path(cut_res_ch3_path)
  trace_feed_in_path = polyline((-0.00117, 0, 0) (-0.00015, 0, 0))
  trace_feed_in = polyline((-0.00117, 5e-06, 0) (-0.00117, -5e-06, 0))
  trace_feed_in.sweep_along_path(trace_feed_in_path)
  cut_feed_in_path = polyline((-0.00117, 0, 0) (-0.00015, 0, 0))
  cut_feed_in = polyline((-0.00117, 1.1e-05, 0) (-0.00117, -1.1e-05, 0))
  cut_feed_in.sweep_along_path(cut_feed_in_path)
  trace_feed_out_path = polyline((0.00015, 0, 0) (0.00117, 0, 0))
  trace_feed_out = polyline((0.00015, 5e-06, 0) (0.00015, -5e-06, 0))
  trace_feed_out.sweep_along_path(trace_feed_out_path)
  cut_feed_out_path = polyline((0.00015, 0, 0) (0.00117, 0, 0))
  cut_feed_out = polyline((0.00015, 1.1e-05, 0) (0.00015, -1.1e-05, 0))
  cut_feed_out.sweep_along_path(cut_feed_out_path)
  g_wb [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-5.5e-05 YPadPos=-0.000765 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_1 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-5.5e-05 YPadPos=-0.001115 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_2 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000255 YPadPos=-0.0025316667 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_3 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000255 YPadPos=-0.0021483333 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_4 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0012568124 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_5 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0015986249 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_6 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0019404373 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_7 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=5.5e-05 YPadPos=-0.0020236249 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_8 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.002174872 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_9 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001797404 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_10 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001419936 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_11 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001042468 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_12 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000145 YPadPos=-0.00093166667 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_13 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000145 YPadPos=-0.0011983333 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_14 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00083 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_15 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00049 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_16 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00049 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_17 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00083 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  tap_trace_n0_ch3 = polyline(z=0, xy: (-5e-06, -0.0001) (-5e-06, -5e-06) (-0.00015, -5e-06) (-0.00015, 5e-06) (0.00015, 5e-06) (0.00015, -5e-06) (5e-06, -5e-06) (5e-06, -0.0001) (-5e-06, -0.0001), closed, covered)
  tap_cut_n0_ch3 = polyline(z=0, xy: (-1.1e-05, -0.0001) (-1.1e-05, -1.1e-05) (-0.00015, -1.1e-05) (-0.00015, 1.1e-05) (0.00015, 1.1e-05) (0.00015, -1.1e-05) (1.1e-05, -1.1e-05) (1.1e-05, -0.0001) (-1.1e-05, -0.0001), closed, covered)
  plate_cp_ch3 = polyline(z=0, xy: (8.25e-05, -0.000295) (8.2461478e-05, -0.00029578414) (8.2346282e-05, -0.00029656072) (8.2155523e-05, -0.00029732228) (8.1891036e-05, -0.00029806147) (8.155537e-05, -0.00029877117) (8.1151757e-05, -0.00029944456) (8.0684084e-05, -0.00030007515) (8.0156854e-05, -0.00030065685) (7.9575146e-05, -0.00030118408) (7.8944562e-05, -0.00030165176) (7.8271174e-05, -0.00030205537) (7.7561467e-05, -0.00030239104) (7.6822277e-05, -0.00030265552) (7.6060723e-05, -0.00030284628) (7.5284137e-05, -0.00030296148) (7.45e-05, -0.000303) (-7.45e-05, -0.000303) (-7.5284137e-05, -0.00030296148) (-7.6060723e-05, -0.00030284628) (-7.6822277e-05, -0.00030265552) (-7.7561467e-05, -0.00030239104) (-7.8271174e-05, -0.00030205537) (-7.8944562e-05, -0.00030165176) (-7.9575146e-05, -0.00030118408) (-8.0156854e-05, -0.00030065685) (-8.0684084e-05, -0.00030007515) (-8.1151757e-05, -0.00029944456) (-8.155537e-05, -0.00029877117) (-8.1891036e-05, -0.00029806147) (-8.2155523e-05, -0.00029732228) (-8.2346282e-05, -0.00029656072) (-8.2461478e-05, -0.00029578414) (-8.25e-05, -0.000295) (-8.25e-05, -0.00027) (-8.2461478e-05, -0.00026921586) (-8.2346282e-05, -0.00026843928) (-8.2155523e-05, -0.00026767772) (-8.1891036e-05, -0.00026693853) (-8.155537e-05, -0.00026622883) (-8.1151757e-05, -0.00026555544) (-8.0684084e-05, -0.00026492485) (-8.0156854e-05, -0.00026434315) (-7.9575146e-05, -0.00026381592) (-7.8944562e-05, -0.00026334824) (-7.8271174e-05, -0.00026294463) (-7.7561467e-05, -0.00026260896) (-7.6822277e-05, -0.00026234448) (-7.6060723e-05, -0.00026215372) (-7.5284137e-05, -0.00026203852) (-7.45e-05, -0.000262) (7.45e-05, -0.000262) (7.5284137e-05, -0.00026203852) (7.6060723e-05, -0.00026215372) (7.6822277e-05, -0.00026234448) (7.7561467e-05, -0.00026260896) (7.8271174e-05, -0.00026294463) (7.8944562e-05, -0.00026334824) (7.9575146e-05, -0.00026381592) (8.0156854e-05, -0.00026434315) (8.0684084e-05, -0.00026492485) (8.1151757e-05, -0.00026555544) (8.155537e-05, -0.00026622883) (8.1891036e-05, -0.00026693853) (8.2155523e-05, -0.00026767772) (8.2346282e-05, -0.00026843928) (8.2461478e-05, -0.00026921586) (8.25e-05, -0.00027) (8.25e-05, -0.000295), closed, covered)
  frame_cp_ch3 = polyline(z=0, xy: (8.25e-05, -0.000311) (8.3284137e-05, -0.00031096148) (8.4060723e-05, -0.00031084628) (8.4822277e-05, -0.00031065552) (8.5561467e-05, -0.00031039104) (8.6271174e-05, -0.00031005537) (8.6944562e-05, -0.00030965176) (8.7575146e-05, -0.00030918408) (8.8156854e-05, -0.00030865685) (8.8684084e-05, -0.00030807515) (8.9151757e-05, -0.00030744456) (8.955537e-05, -0.00030677117) (8.9891036e-05, -0.00030606147) (9.0155523e-05, -0.00030532228) (9.0346282e-05, -0.00030456072) (9.0461478e-05, -0.00030378414) (9.05e-05, -0.000303) (9.05e-05, -0.000262) (9.0461478e-05, -0.00026121586) (9.0346282e-05, -0.00026043928) (9.0155523e-05, -0.00025967772) (8.9891036e-05, -0.00025893853) (8.955537e-05, -0.00025822883) (8.9151757e-05, -0.00025755544) (8.8684084e-05, -0.00025692485) (8.8156854e-05, -0.00025634315) (8.7575146e-05, -0.00025581592) (8.6944562e-05, -0.00025534824) (8.6271174e-05, -0.00025494463) (8.5561467e-05, -0.00025460896) (8.4822277e-05, -0.00025434448) (8.4060723e-05, -0.00025415372) (8.3284137e-05, -0.00025403852) (8.25e-05, -0.000254) (1.909818e-05, -0.000254) (1.8901939e-05, -0.00025399518) (1.8412015e-05, -0.00025397111) (1.80216e-05, -0.00025393266) (1.7633541e-05, -0.0002538751) (1.7248774e-05, -0.00025379856) (1.6868226e-05, -0.00025370324) (1.6492814e-05, -0.00025358936) (1.6123441e-05, -0.0002534572) (1.5760999e-05, -0.00025330707) (1.540636e-05, -0.00025313934) (1.5060378e-05, -0.00025295441) (1.4723887e-05, -0.00025275272) (1.4397697e-05, -0.00025253477) (1.4082595e-05, -0.00025230107) (1.3779339e-05, -0.0002520522) (1.348866e-05, -0.00025178874) (1.3211259e-05, -0.00025151134) (1.2947803e-05, -0.00025122066) (1.2698928e-05, -0.0002509174) (1.2465232e-05, -0.0002506023) (1.2247279e-05, -0.00025027611) (1.2045594e-05, -0.00024993962) (1.1860663e-05, -0.00024959364) (1.1692931e-05, -0.000249239) (1.1542802e-05, -0.00024887656) (1.1410639e-05, -0.00024850719) (1.1296759e-05, -0.00024813177) (1.1201436e-05, -0.00024775123) (1.1124902e-05, -0.00024736646) (1.1067338e-05, -0.0002469784) (1.1028886e-05, -0.00024658799) (1.1004817e-05, -0.00024609806) (1.1e-05, -0.00024590182) (1.1e-05, -0.00019809818) (1.1004817e-05, -0.00019790194) (1.1028886e-05, -0.00019741201) (1.1067338e-05, -0.0001970216) (1.1124902e-05, -0.00019663354) (1.1201436e-05, -0.00019624877) (1.1296759e-05, -0.00019586823) (1.1410639e-05, -0.00019549281) (1.1542802e-05, -0.00019512344) (1.1692931e-05, -0.000194761) (1.1860663e-05, -0.00019440636) (1.2045594e-05, -0.00019406038) (1.2247279e-05, -0.00019372389) (1.2465232e-05, -0.0001933977) (1.2698928e-05, -0.00019308259) (1.2947803e-05, -0.00019277934) (1.3211259e-05, -0.00019248866) (1.348866e-05, -0.00019221126) (1.3779339e-05, -0.0001919478) (1.4082595e-05, -0.00019169893) (1.4397697e-05, -0.00019146523) (1.4723887e-05, -0.00019124728) (1.5060378e-05, -0.00019104559) (1.540636e-05, -0.00019086066) (1.5760999e-05, -0.00019069293) (1.6123441e-05, -0.0001905428) (1.6492814e-05, -0.00019041064) (1.6868226e-05, -0.00019029676) (1.7248774e-05, -0.00019020144) (1.7633541e-05, -0.0001901249) (1.80216e-05, -0.00019006734) (1.8412015e-05, -0.00019002889) (1.8901939e-05, -0.00019000482) (1.909818e-05, -0.00019) (0.00013940182, -0.00019) (0.00013959806, -0.00019000482) (0.00014008798, -0.00019002889) (0.0001404784, -0.00019006734) (0.00014086646, -0.0001901249) (0.00014125123, -0.00019020144) (0.00014163177, -0.00019029676) (0.00014200719, -0.00019041064) (0.00014237656, -0.0001905428) (0.000142739, -0.00019069293) (0.00014309364, -0.00019086066) (0.00014343962, -0.00019104559) (0.00014377611, -0.00019124728) (0.0001441023, -0.00019146523) (0.0001444174, -0.00019169893) (0.00014472066, -0.0001919478) (0.00014501134, -0.00019221126) (0.00014528874, -0.00019248866) (0.0001455522, -0.00019277934) (0.00014580107, -0.00019308259) (0.00014603477, -0.0001933977) (0.00014625272, -0.00019372389) (0.00014645441, -0.00019406038) (0.00014663934, -0.00019440636) (0.00014680707, -0.000194761) (0.0001469572, -0.00019512344) (0.00014708936, -0.00019549281) (0.00014720324, -0.00019586823) (0.00014729856, -0.00019624877) (0.0001473751, -0.00019663354) (0.00014743266, -0.0001970216) (0.00014747111, -0.00019741201) (0.00014749518, -0.00019790194) (0.0001475, -0.00019809818) (0.0001475, -0.00035490182) (0.00014749518, -0.00035509806) (0.00014747111, -0.00035558799) (0.00014743266, -0.0003559784) (0.0001473751, -0.00035636646) (0.00014729856, -0.00035675123) (0.00014720324, -0.00035713177) (0.00014708936, -0.00035750719) (0.0001469572, -0.00035787656) (0.00014680707, -0.000358239) (0.00014663934, -0.00035859364) (0.00014645441, -0.00035893962) (0.00014625272, -0.00035927611) (0.00014603477, -0.0003596023) (0.00014580107, -0.00035991741) (0.0001455522, -0.00036022066) (0.00014528874, -0.00036051134) (0.00014501134, -0.00036078874) (0.00014472066, -0.0003610522) (0.0001444174, -0.00036130107) (0.0001441023, -0.00036153477) (0.00014377611, -0.00036175272) (0.00014343962, -0.00036195441) (0.00014309364, -0.00036213934) (0.000142739, -0.00036230707) (0.00014237656, -0.0003624572) (0.00014200719, -0.00036258936) (0.00014163177, -0.00036270324) (0.00014125123, -0.00036279856) (0.00014086646, -0.0003628751) (0.0001404784, -0.00036293266) (0.00014008798, -0.00036297111) (0.00013959806, -0.00036299518) (0.00013940182, -0.000363) (-0.00013940182, -0.000363) (-0.00013959806, -0.00036299518) (-0.00014008798, -0.00036297111) (-0.0001404784, -0.00036293266) (-0.00014086646, -0.0003628751) (-0.00014125123, -0.00036279856) (-0.00014163177, -0.00036270324) (-0.00014200719, -0.00036258936) (-0.00014237656, -0.0003624572) (-0.000142739, -0.00036230707) (-0.00014309364, -0.00036213934) (-0.00014343962, -0.00036195441) (-0.00014377611, -0.00036175272) (-0.0001441023, -0.00036153477) (-0.0001444174, -0.00036130107) (-0.00014472066, -0.0003610522) (-0.00014501134, -0.00036078874) (-0.00014528874, -0.00036051134) (-0.0001455522, -0.00036022066) (-0.00014580107, -0.00035991741) (-0.00014603477, -0.0003596023) (-0.00014625272, -0.00035927611) (-0.00014645441, -0.00035893962) (-0.00014663934, -0.00035859364) (-0.00014680707, -0.000358239) (-0.0001469572, -0.00035787656) (-0.00014708936, -0.00035750719) (-0.00014720324, -0.00035713177) (-0.00014729856, -0.00035675123) (-0.0001473751, -0.00035636646) (-0.00014743266, -0.0003559784) (-0.00014747111, -0.00035558799) (-0.00014749518, -0.00035509806) (-0.0001475, -0.00035490182) (-0.0001475, -0.00019809818) (-0.00014749518, -0.00019790194) (-0.00014747111, -0.00019741201) (-0.00014743266, -0.0001970216) (-0.0001473751, -0.00019663354) (-0.00014729856, -0.00019624877) (-0.00014720324, -0.00019586823) (-0.00014708936, -0.00019549281) (-0.0001469572, -0.00019512344) (-0.00014680707, -0.000194761) (-0.00014663934, -0.00019440636) (-0.00014645441, -0.00019406038) (-0.00014625272, -0.00019372389) (-0.00014603477, -0.0001933977) (-0.00014580107, -0.00019308259) (-0.0001455522, -0.00019277934) (-0.00014528874, -0.00019248866) (-0.00014501134, -0.00019221126) (-0.00014472066, -0.0001919478) (-0.0001444174, -0.00019169893) (-0.0001441023, -0.00019146523) (-0.00014377611, -0.00019124728) (-0.00014343962, -0.00019104559) (-0.00014309364, -0.00019086066) (-0.000142739, -0.00019069293) (-0.00014237656, -0.0001905428) (-0.00014200719, -0.00019041064) (-0.00014163177, -0.00019029676) (-0.00014125123, -0.00019020144) (-0.00014086646, -0.0001901249) (-0.0001404784, -0.00019006734) (-0.00014008798, -0.00019002889) (-0.00013959806, -0.00019000482) (-0.00013940182, -0.00019) (-1.909818e-05, -0.00019) (-1.8901939e-05, -0.00019000482) (-1.8412015e-05, -0.00019002889) (-1.80216e-05, -0.00019006734) (-1.7633541e-05, -0.0001901249) (-1.7248774e-05, -0.00019020144) (-1.6868226e-05, -0.00019029676) (-1.6492814e-05, -0.00019041064) (-1.6123441e-05, -0.0001905428) (-1.5760999e-05, -0.00019069293) (-1.540636e-05, -0.00019086066) (-1.5060378e-05, -0.00019104559) (-1.4723887e-05, -0.00019124728) (-1.4397697e-05, -0.00019146523) (-1.4082595e-05, -0.00019169893) (-1.3779339e-05, -0.0001919478) (-1.348866e-05, -0.00019221126) (-1.3211259e-05, -0.00019248866) (-1.2947803e-05, -0.00019277934) (-1.2698928e-05, -0.00019308259) (-1.2465232e-05, -0.0001933977) (-1.2247279e-05, -0.00019372389) (-1.2045594e-05, -0.00019406038) (-1.1860663e-05, -0.00019440636) (-1.1692931e-05, -0.000194761) (-1.1542802e-05, -0.00019512344) (-1.1410639e-05, -0.00019549281) (-1.1296759e-05, -0.00019586823) (-1.1201436e-05, -0.00019624877) (-1.1124902e-05, -0.00019663354) (-1.1067338e-05, -0.0001970216) (-1.1028886e-05, -0.00019741201) (-1.1004817e-05, -0.00019790194) (-1.1e-05, -0.00019809818) (-1.1e-05, -0.00024590182) (-1.1004817e-05, -0.00024609806) (-1.1028886e-05, -0.00024658799) (-1.1067338e-05, -0.0002469784) (-1.1124902e-05, -0.00024736646) (-1.1201436e-05, -0.00024775123) (-1.1296759e-05, -0.00024813177) (-1.1410639e-05, -0.00024850719) (-1.1542802e-05, -0.00024887656) (-1.1692931e-05, -0.000249239) (-1.1860663e-05, -0.00024959364) (-1.2045594e-05, -0.00024993962) (-1.2247279e-05, -0.00025027611) (-1.2465232e-05, -0.0002506023) (-1.2698928e-05, -0.0002509174) (-1.2947803e-05, -0.00025122066) (-1.3211259e-05, -0.00025151134) (-1.348866e-05, -0.00025178874) (-1.3779339e-05, -0.0002520522) (-1.4082595e-05, -0.00025230107) (-1.4397697e-05, -0.00025253477) (-1.4723887e-05, -0.00025275272) (-1.5060378e-05, -0.00025295441) (-1.540636e-05, -0.00025313934) (-1.5760999e-05, -0.00025330707) (-1.6123441e-05, -0.0002534572) (-1.6492814e-05, -0.00025358936) (-1.6868226e-05, -0.00025370324)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, closed, covered)
  pocket_cp_ch3 = polyline(z=0, xy: (0.0001475, -0.000375) (-0.0001475, -0.000375) (-0.00014867621, -0.00037494222) (-0.00014984108, -0.00037476942) (-0.00015098342, -0.00037448328) (-0.0001520922, -0.00037408655) (-0.00015315676, -0.00037358305) (-0.00015416684, -0.00037297763) (-0.00015511272, -0.00037227612) (-0.00015598528, -0.00037148528) (-0.00015677613, -0.00037061272) (-0.00015747764, -0.00036966684) (-0.00015808305, -0.00036865676) (-0.00015858655, -0.0003675922) (-0.00015898328, -0.00036648342) (-0.00015926942, -0.00036534108) (-0.00015944222, -0.00036417621) (-0.0001595, -0.000363) (-0.0001595, -0.00019) (-0.00015944222, -0.00018882379) (-0.00015926942, -0.00018765892) (-0.00015898328, -0.00018651658) (-0.00015858655, -0.0001854078) (-0.00015808305, -0.00018434324) (-0.00015747764, -0.00018333316) (-0.00015677613, -0.00018238728) (-0.00015598528, -0.00018151472) (-0.00015511272, -0.00018072388) (-0.00015416684, -0.00018002237) (-0.00015315676, -0.00017941694) (-0.0001520922, -0.00017891345) (-0.00015098342, -0.00017851672) (-0.00014984108, -0.00017823058) (-0.00014867621, -0.00017805778) (-0.0001475, -0.000178) (0.0001475, -0.000178) (0.00014867621, -0.00017805778) (0.00014984108, -0.00017823058) (0.00015098342, -0.00017851672) (0.0001520922, -0.00017891345) (0.00015315676, -0.00017941694) (0.00015416684, -0.00018002237) (0.00015511272, -0.00018072388) (0.00015598528, -0.00018151472) (0.00015677613, -0.00018238728) (0.00015747764, -0.00018333316) (0.00015808305, -0.00018434324) (0.00015858655, -0.0001854078) (0.00015898328, -0.00018651658) (0.00015926942, -0.00018765892) (0.00015944222, -0.00018882379) (0.0001595, -0.00019) (0.0001595, -0.000363) (0.00015944222, -0.00036417621) (0.00015926942, -0.00036534108) (0.00015898328, -0.00036648342) (0.00015858655, -0.0003675922) (0.00015808305, -0.00036865676) (0.00015747764, -0.00036966684) (0.00015677613, -0.00037061272) (0.00015598528, -0.00037148528) (0.00015511272, -0.00037227612) (0.00015416684, -0.00037297763) (0.00015315676, -0.00037358305) (0.0001520922, -0.00037408655) (0.00015098342, -0.00037448328) (0.00014984108, -0.00037476942) (0.00014867621, -0.00037494222) (0.0001475, -0.000375), closed, covered)
  tap_trace_jf_ch3 = polyline(z=0, xy: (5e-06, -0.001465) (5e-06, -0.00161) (3.55e-05, -0.00161) (3.55e-05, -0.00162) (5e-06, -0.00162) (5e-06, -0.001765) (-5e-06, -0.001765) (-5e-06, -0.001465) (5e-06, -0.001465), closed, covered)
  tap_cut_jf_ch3 = polyline(z=0, xy: (1.1e-05, -0.001465) (1.1e-05, -0.001604) (3.55e-05, -0.001604) (3.55e-05, -0.001626) (1.1e-05, -0.001626) (1.1e-05, -0.001765) (-1.1e-05, -0.001765) (-1.1e-05, -0.001465) (1.1e-05, -0.001465), closed, covered)
  tap_trace_jr_ch3 = polyline(z=0, xy: (0.0001645, -0.00161) (0.000195, -0.00161) (0.000195, -0.001465) (0.000205, -0.001465) (0.000205, -0.001765) (0.000195, -0.001765) (0.000195, -0.00162) (0.0001645, -0.00162) (0.0001645, -0.00161), closed, covered)
  tap_cut_jr_ch3 = polyline(z=0, xy: (0.0001645, -0.001604) (0.000189, -0.001604) (0.000189, -0.001465) (0.000211, -0.001465) (0.000211, -0.001765) (0.000189, -0.001765) (0.000189, -0.001626) (0.0001645, -0.001626) (0.0001645, -0.001604), closed, covered)
  head_a_cj_ch3 = polyline(z=0, xy: (6.75e-05, -0.0016475) (6.7303966e-05, -0.0016474904) (6.7109819e-05, -0.0016474616) (6.6919431e-05, -0.0016474139) (6.6734633e-05, -0.0016473478) (6.6557207e-05, -0.0016472638) (6.638886e-05, -0.0016471629) (6.6231213e-05, -0.001647046) (6.6085786e-05, -0.0016469142) (6.5953979e-05, -0.0016467688) (6.5837061e-05, -0.0016466111) (6.5736157e-05, -0.0016464428) (6.5652241e-05, -0.0016462654) (6.5586119e-05, -0.0016460806) (6.5538429e-05, -0.0016458902) (6.5509631e-05, -0.001645696) (6.55e-05, -0.0016455) (6.55e-05, -0.0015845) (6.5509631e-05, -0.001584304) (6.5538429e-05, -0.0015841098) (6.5586119e-05, -0.0015839194) (6.5652241e-05, -0.0015837346) (6.5736157e-05, -0.0015835572) (6.5837061e-05, -0.0015833889) (6.5953979e-05, -0.0015832312) (6.6085786e-05, -0.0015830858) (6.6231213e-05, -0.001582954) (6.638886e-05, -0.0015828371) (6.6557207e-05, -0.0015827362) (6.6734633e-05, -0.0015826522) (6.6919431e-05, -0.0015825861) (6.7109819e-05, -0.0015825384) (6.7303966e-05, -0.0015825096) (6.75e-05, -0.0015825) (8.85e-05, -0.0015825) (8.8696034e-05, -0.0015825096) (8.8890181e-05, -0.0015825384) (8.9080569e-05, -0.0015825861) (8.9265367e-05, -0.0015826522) (8.9442793e-05, -0.0015827362) (8.961114e-05, -0.0015828371) (8.9768787e-05, -0.001582954) (8.9914214e-05, -0.0015830858) (9.0046021e-05, -0.0015832312) (9.0162939e-05, -0.0015833889) (9.0263843e-05, -0.0015835572) (9.0347759e-05, -0.0015837346) (9.0413881e-05, -0.0015839194) (9.0461571e-05, -0.0015841098) (9.0490369e-05, -0.001584304) (9.05e-05, -0.0015845) (9.05e-05, -0.0016455) (9.0490369e-05, -0.001645696) (9.0461571e-05, -0.0016458902) (9.0413881e-05, -0.0016460806) (9.0347759e-05, -0.0016462654) (9.0263843e-05, -0.0016464428) (9.0162939e-05, -0.0016466111) (9.0046021e-05, -0.0016467688) (8.9914214e-05, -0.0016469142) (8.9768787e-05, -0.001647046) (8.961114e-05, -0.0016471629) (8.9442793e-05, -0.0016472638) (8.9265367e-05, -0.0016473478) (8.9080569e-05, -0.0016474139) (8.8890181e-05, -0.0016474616) (8.8696034e-05, -0.0016474904) (8.85e-05, -0.0016475) (6.75e-05, -0.0016475), closed, covered)
  head_b_cj_ch3 = polyline(z=0, xy: (0.0001115, -0.0016475) (0.00011130397, -0.0016474904) (0.00011110982, -0.0016474616) (0.00011091943, -0.0016474139) (0.00011073463, -0.0016473478) (0.00011055721, -0.0016472638) (0.00011038886, -0.0016471629) (0.00011023121, -0.001647046) (0.00011008579, -0.0016469142) (0.00010995398, -0.0016467688) (0.00010983706, -0.0016466111) (0.00010973616, -0.0016464428) (0.00010965224, -0.0016462654) (0.00010958612, -0.0016460806) (0.00010953843, -0.0016458902) (0.00010950963, -0.001645696) (0.0001095, -0.0016455) (0.0001095, -0.0015845) (0.00010950963, -0.001584304) (0.00010953843, -0.0015841098) (0.00010958612, -0.0015839194) (0.00010965224, -0.0015837346) (0.00010973616, -0.0015835572) (0.00010983706, -0.0015833889) (0.00010995398, -0.0015832312) (0.00011008579, -0.0015830858) (0.00011023121, -0.001582954) (0.00011038886, -0.0015828371) (0.00011055721, -0.0015827362) (0.00011073463, -0.0015826522) (0.00011091943, -0.0015825861) (0.00011110982, -0.0015825384) (0.00011130397, -0.0015825096) (0.0001115, -0.0015825) (0.0001325, -0.0015825) (0.00013269603, -0.0015825096) (0.00013289018, -0.0015825384) (0.00013308057, -0.0015825861) (0.00013326537, -0.0015826522) (0.00013344279, -0.0015827362) (0.00013361114, -0.0015828371) (0.00013376879, -0.001582954) (0.00013391421, -0.0015830858) (0.00013404602, -0.0015832312) (0.00013416294, -0.0015833889) (0.00013426384, -0.0015835572) (0.00013434776, -0.0015837346) (0.00013441388, -0.0015839194) (0.00013446157, -0.0015841098) (0.00013449037, -0.001584304) (0.0001345, -0.0015845) (0.0001345, -0.0016455) (0.00013449037, -0.001645696) (0.00013446157, -0.0016458902) (0.00013441388, -0.0016460806) (0.00013434776, -0.0016462654) (0.00013426384, -0.0016464428) (0.00013416294, -0.0016466111) (0.00013404602, -0.0016467688) (0.00013391421, -0.0016469142) (0.00013376879, -0.001647046) (0.00013361114, -0.0016471629) (0.00013344279, -0.0016472638) (0.00013326537, -0.0016473478) (0.00013308057, -0.0016474139) (0.00013289018, -0.0016474616) (0.00013269603, -0.0016474904) (0.0001325, -0.0016475) (0.0001115, -0.0016475), closed, covered)
  pocket_cj_ch3 = polyline(z=0, xy: (5.15e-05, -0.0016635) (5.1303966e-05, -0.0016634904) (5.1109819e-05, -0.0016634616) (5.0919431e-05, -0.0016634139) (5.0734633e-05, -0.0016633478) (5.0557207e-05, -0.0016632638) (5.038886e-05, -0.0016631629) (5.0231213e-05, -0.001663046) (5.0085786e-05, -0.0016629142) (4.9953979e-05, -0.0016627688) (4.9837061e-05, -0.0016626111) (4.9736157e-05, -0.0016624428) (4.9652241e-05, -0.0016622654) (4.9586119e-05, -0.0016620806) (4.9538429e-05, -0.0016618902) (4.9509631e-05, -0.001661696) (4.95e-05, -0.0016615) (4.95e-05, -0.0015685) (4.9509631e-05, -0.001568304) (4.9538429e-05, -0.0015681098) (4.9586119e-05, -0.0015679194) (4.9652241e-05, -0.0015677346) (4.9736157e-05, -0.0015675572) (4.9837061e-05, -0.0015673889) (4.9953979e-05, -0.0015672312) (5.0085786e-05, -0.0015670858) (5.0231213e-05, -0.001566954) (5.038886e-05, -0.0015668371) (5.0557207e-05, -0.0015667362) (5.0734633e-05, -0.0015666522) (5.0919431e-05, -0.0015665861) (5.1109819e-05, -0.0015665384) (5.1303966e-05, -0.0015665096) (5.15e-05, -0.0015665) (0.0001485, -0.0015665) (0.00014869603, -0.0015665096) (0.00014889018, -0.0015665384) (0.00014908057, -0.0015665861) (0.00014926537, -0.0015666522) (0.00014944279, -0.0015667362) (0.00014961114, -0.0015668371) (0.00014976879, -0.001566954) (0.00014991421, -0.0015670858) (0.00015004602, -0.0015672312) (0.00015016294, -0.0015673889) (0.00015026384, -0.0015675572) (0.00015034776, -0.0015677346) (0.00015041388, -0.0015679194) (0.00015046157, -0.0015681098) (0.00015049037, -0.001568304) (0.0001505, -0.0015685) (0.0001505, -0.0016615) (0.00015049037, -0.001661696) (0.00015046157, -0.0016618902) (0.00015041388, -0.0016620806) (0.00015034776, -0.0016622654) (0.00015026384, -0.0016624428) (0.00015016294, -0.0016626111) (0.00015004602, -0.0016627688) (0.00014991421, -0.0016629142) (0.00014976879, -0.001663046) (0.00014961114, -0.0016631629) (0.00014944279, -0.0016632638) (0.00014926537, -0.0016633478) (0.00014908057, -0.0016634139) (0.00014889018, -0.0016634616) (0.00014869603, -0.0016634904) (0.0001485, -0.0016635) (5.15e-05, -0.0016635), closed, covered)
  endcap_res_a_ch3_start = rectangle(corner=(0.000189, -0.002921, 0), x_size=2.2e-05, y_size=6e-06)
  endcap_feed_in_start = rectangle(corner=(-0.001176, -1.1e-05, 0), x_size=6e-06, y_size=2.2e-05)
  endcap_feed_out_end = rectangle(corner=(0.00117, -1.1e-05, 0), x_size=6e-06, y_size=2.2e-05)
  ground_main_plane = rectangle(corner=(-0.00137, -0.003115, 0), x_size=0.00274, y_size=0.003326)
  main [silicon] = box(corner=(-0.00137, -0.003115, -0.000525), size=(0.00274, 0.003326, 0.000525))
  sample_holder [vacuum] = box(corner=(-0.00137, -0.003115, -0.00165), size=(0.00274, 0.003326, 0.00254))
  ground_main_plane.subtract(pocket_cp_ch3, cut_stub_p_ch3, tap_cut_jr_ch3, cut_stub_r_ch3, lead_b_sub_cj_ch3, lead_a_sub_cj_ch3, cut_res_a_ch3, cut_stub_f_ch3, cut_res_ch3, tap_cut_n0_ch3, tap_cut_jf_ch3, pocket_cj_ch3, cut_feed_in, endcap_res_a_ch3_start, lead_a_sub_cp_ch3, cut_filt_ch3, lead_b_sub_cp_ch3, cut_feed_jf_ch3, endcap_feed_out_end, endcap_feed_in_start, cut_feed_out)
  Port_feed_in_start = rectangle(corner=(-0.001176, -5e-06, 0), x_size=6e-06, y_size=1e-05)
  voltage_line_Port_feed_in_start = polyline((-0.00117, 0, 0) (-0.001176, 0, 0))
  Port_feed_out_end = rectangle(corner=(0.00117, -5e-06, 0), x_size=6e-06, y_size=1e-05)
  voltage_line_Port_feed_out_end = polyline((0.00117, 0, 0) (0.001176, 0, 0))
boundaries and excitations:
  RLCBoundary_feed_in_start: Lumped RLC Objects=Port_feed_in_start CurrentLine{middle of Port_feed_in_start.edge(x at corner) -> middle of Port_feed_in_start.edge(x opposite corner)} RLC_Type=Parallel Resistance=50ohm
  RLCBoundary_feed_out_end: Lumped RLC Objects=Port_feed_out_end CurrentLine{middle of Port_feed_out_end.edge(x at corner) -> middle of Port_feed_out_end.edge(x opposite corner)} RLC_Type=Parallel Resistance=50ohm
  PerfE: Perfect E Objects=[lead_a_cp_ch3, lead_b_cp_ch3, trace_stub_p_ch3, trace_feed_jf_ch3, lead_a_cj_ch3, lead_b_cj_ch3, trace_stub_f_ch3, trace_stub_r_ch3, trace_res_a_ch3, trace_filt_ch3, trace_res_ch3, trace_feed_in, trace_feed_out, tap_trace_n0_ch3, plate_cp_ch3, frame_cp_ch3, tap_trace_jf_ch3, tap_trace_jr_ch3, head_a_cj_ch3, head_b_cj_ch3, ground_main_plane]
mesh:
  port_mesh: LengthBased Objects=[Port_feed_in_start, Port_feed_out_end] MaxLength=7um
  cpw_line_mesh: LengthBased Objects=[trace_stub_p_ch3, trace_feed_jf_ch3, trace_stub_f_ch3, trace_stub_r_ch3, trace_res_a_ch3, trace_filt_ch3, trace_res_ch3, trace_feed_in, trace_feed_out, tap_trace_n0_ch3, tap_trace_jf_ch3, tap_trace_jr_ch3] MaxLength=10um
  cap_mesh: LengthBased Objects=[lead_a_cp_ch3, lead_b_cp_ch3, lead_a_cj_ch3, lead_b_cj_ch3, plate_cp_ch3, frame_cp_ch3, head_a_cj_ch3, head_b_cj_ch3] MaxLength=5um
setups:
  Setup: HfssEigen MinimumFrequency=5.5GHz NumModes=4 MaxDeltaFreq=0.1 ConvergeOnRealFreq=true MaximumPasses=3 MinimumPasses=3 MinimumConvergedPasses=2 PercentRefinement=20 BasisOrder=1
source amplitudes:
  #-10:1: 1 0deg
  #-10:2, #-10:3, #-10:4: 0 0deg
reports:
  Eigen Modes Plot 1: re(Mode(1)), re(Mode(2)), re(Mode(3)), re(Mode(4)) vs Pass on Setup : AdaptivePass

design q3d6_full_2056_q3d (Q3D Extractor, model units mm)
options: SParamCalcMethod=EqTransLine Calculate_Lossy_Dielectrics
geometry:
  lead_a_cp_ch3_path = polyline((0, -0.000362999, 0) (0, -0.000415, 0))
  lead_a_cp_ch3 [copper] = polyline((5e-06, -0.000362999, 0) (-5e-06, -0.000362999, 0))
  lead_a_cp_ch3.sweep_along_path(lead_a_cp_ch3_path)
  lead_a_sub_cp_ch3_path = polyline((0, -0.000362999, 0) (0, -0.000415, 0))
  lead_a_sub_cp_ch3 = polyline((1.1e-05, -0.000362999, 0) (-1.1e-05, -0.000362999, 0))
  lead_a_sub_cp_ch3.sweep_along_path(lead_a_sub_cp_ch3_path)
  lead_b_cp_ch3_path = polyline((0, -0.000262001, 0) (0, -0.00015, 0))
  lead_b_cp_ch3 [copper] = polyline((-5e-06, -0.000262001, 0) (5e-06, -0.000262001, 0))
  lead_b_cp_ch3.sweep_along_path(lead_b_cp_ch3_path)
  lead_b_sub_cp_ch3_path = polyline((0, -0.000262001, 0) (0, -0.00015, 0))
  lead_b_sub_cp_ch3 = polyline((-1.1e-05, -0.000262001, 0) (1.1e-05, -0.000262001, 0))
  lead_b_sub_cp_ch3.sweep_along_path(lead_b_sub_cp_ch3_path)
  trace_stub_p_ch3_path = polyline((0, -0.0001, 0) (0, -0.00015, 0))
  trace_stub_p_ch3 [copper] = polyline((5e-06, -0.0001, 0) (-5e-06, -0.0001, 0))
  trace_stub_p_ch3.sweep_along_path(trace_stub_p_ch3_path)
  cut_stub_p_ch3_path = polyline((0, -0.0001, 0) (0, -0.00015, 0))
  cut_stub_p_ch3 = polyline((1.1e-05, -0.0001, 0) (-1.1e-05, -0.0001, 0))
  cut_stub_p_ch3.sweep_along_path(cut_stub_p_ch3_path)
  trace_feed_jf_ch3_path = polyline((0, -0.000415, 0) (0, -0.001465, 0))
  trace_feed_jf_ch3 [copper] = polyline((5e-06, -0.000415, 0) (-5e-06, -0.000415, 0))
  trace_feed_jf_ch3.sweep_along_path(trace_feed_jf_ch3_path)
  cut_feed_jf_ch3_path = polyline((0, -0.000415, 0) (0, -0.001465, 0))
  cut_feed_jf_ch3 = polyline((1.1e-05, -0.000415, 0) (-1.1e-05, -0.000415, 0))
  cut_feed_jf_ch3.sweep_along_path(cut_feed_jf_ch3_path)
  lead_a_cj_ch3_path = polyline((6.0001e-05, -0.001615, 0) (5e-05, -0.001615, 0))
  lead_a_cj_ch3 [copper] = polyline((6.0001e-05, -0.00162, 0) (6.0001e-05, -0.00161, 0))
  lead_a_cj_ch3.sweep_along_path(lead_a_cj_ch3_path)
  lead_a_sub_cj_ch3_path = polyline((6.0001e-05, -0.001615, 0) (5e-05, -0.001615, 0))
  lead_a_sub_cj_ch3 = polyline((6.0001e-05, -0.001626, 0) (6.0001e-05, -0.001604, 0))
  lead_a_sub_cj_ch3.sweep_along_path(lead_a_sub_cj_ch3_path)
  lead_b_cj_ch3_path = polyline((0.000139999, -0.001615, 0) (0.00015, -0.001615, 0))
  lead_b_cj_ch3 [copper] = polyline((0.000139999, -0.00161, 0) (0.000139999, -0.00162, 0))
  lead_b_cj_ch3.sweep_along_path(lead_b_cj_ch3_path)
  lead_b_sub_cj_ch3_path = polyline((0.000139999, -0.001615, 0) (0.00015, -0.001615, 0))
  lead_b_sub_cj_ch3 = polyline((0.000139999, -0.001604, 0) (0.000139999, -0.001626, 0))
  lead_b_sub_cj_ch3.sweep_along_path(lead_b_sub_cj_ch3_path)
  trace_stub_f_ch3_path = polyline((3e-05, -0.001615, 0) (5e-05, -0.001615, 0))
  trace_stub_f_ch3 [copper] = polyline((3e-05, -0.00161, 0) (3e-05, -0.00162, 0))
  trace_stub_f_ch3.sweep_along_path(trace_stub_f_ch3_path)
  cut_stub_f_ch3_path = polyline((3e-05, -0.001615, 0) (5e-05, -0.001615, 0))
  cut_stub_f_ch3 = polyline((3e-05, -0.001604, 0) (3e-05, -0.001626, 0))
  cut_stub_f_ch3.sweep_along_path(cut_stub_f_ch3_path)
  trace_stub_r_ch3_path = polyline((0.00017, -0.001615, 0) (0.00015, -0.001615, 0))
  trace_stub_r_ch3 [copper] = polyline((0.00017, -0.00162, 0) (0.00017, -0.00161, 0))
  trace_stub_r_ch3.sweep_along_path(trace_stub_r_ch3_path)
  cut_stub_r_ch3_path = polyline((0.00017, -0.001615, 0) (0.00015, -0.001615, 0))
  cut_stub_r_ch3 = polyline((0.00017, -0.001626, 0) (0.00017, -0.001604, 0))
  cut_stub_r_ch3.sweep_along_path(cut_stub_r_ch3_path)
  trace_res_a_ch3_path = polyline((0.0002, -0.002915, 0) (0.0002, -0.001765, 0))
  trace_res_a_ch3 [copper] = polyline((0.000195, -0.002915, 0) (0.000205, -0.002915, 0))
  trace_res_a_ch3.sweep_along_path(trace_res_a_ch3_path)
  cut_res_a_ch3_path = polyline((0.0002, -0.002915, 0) (0.0002, -0.001765, 0))
  cut_res_a_ch3 = polyline((0.000189, -0.002915, 0) (0.000211, -0.002915, 0))
  cut_res_a_ch3.sweep_along_path(cut_res_a_ch3_path)
  trace_filt_ch3_path = polyline(z=0, xy: (-0.0003, -0.000915) (-0.0003, -0.0022822498) (0, -0.0022822498) (0, -0.001765))
  trace_filt_ch3_path.fillet(Vertices=trace_filt_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  trace_filt_ch3 [copper] = polyline((-0.000295, -0.000915, 0) (-0.000305, -0.000915, 0))
  trace_filt_ch3.sweep_along_path(trace_filt_ch3_path)
  cut_filt_ch3_path = polyline(z=0, xy: (-0.0003, -0.000915) (-0.0003, -0.0022822498) (0, -0.0022822498) (0, -0.001765))
  cut_filt_ch3_path.fillet(Vertices=cut_filt_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  cut_filt_ch3 = polyline((-0.000289, -0.000915, 0) (-0.000311, -0.000915, 0))
  cut_filt_ch3.sweep_along_path(cut_filt_ch3_path)
  trace_res_ch3_path = polyline(z=0, xy: (0.00055, -0.00255234) (0.00055, -0.000665) (0.0002, -0.000665) (0.0002, -0.001465))
  trace_res_ch3_path.fillet(Vertices=trace_res_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  trace_res_ch3 [copper] = polyline((0.000545, -0.00255234, 0) (0.000555, -0.00255234, 0))
  trace_res_ch3.sweep_along_path(trace_res_ch3_path)
  cut_res_ch3_path = polyline(z=0, xy: (0.00055, -0.00255234) (0.00055, -0.000665) (0.0002, -0.000665) (0.0002, -0.001465))
  cut_res_ch3_path.fillet(Vertices=cut_res_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  cut_res_ch3 = polyline((0.000539, -0.00255234, 0) (0.000561, -0.00255234, 0))
  cut_res_ch3.sweep_along_path(cut_res_ch3_path)
  trace_feed_in_path = polyline((-0.00117, 0, 0) (-0.00015, 0, 0))
  trace_feed_in [copper] = polyline((-0.00117, 5e-06, 0) (-0.00117, -5e-06, 0))
  trace_feed_in.sweep_along_path(trace_feed_in_path)
  cut_feed_in_path = polyline((-0.00117, 0, 0) (-0.00015, 0, 0))
  cut_feed_in = polyline((-0.00117, 1.1e-05, 0) (-0.00117, -1.1e-05, 0))
  cut_feed_in.sweep_along_path(cut_feed_in_path)
  trace_feed_out_path = polyline((0.00015, 0, 0) (0.00117, 0, 0))
  trace_feed_out [copper] = polyline((0.00015, 5e-06, 0) (0.00015, -5e-06, 0))
  trace_feed_out.sweep_along_path(trace_feed_out_path)
  cut_feed_out_path = polyline((0.00015, 0, 0) (0.00117, 0, 0))
  cut_feed_out = polyline((0.00015, 1.1e-05, 0) (0.00015, -1.1e-05, 0))
  cut_feed_out.sweep_along_path(cut_feed_out_path)
  g_wb [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-5.5e-05 YPadPos=-0.000765 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_1 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-5.5e-05 YPadPos=-0.001115 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_2 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000255 YPadPos=-0.0025316667 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_3 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000255 YPadPos=-0.0021483333 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_4 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0012568124 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_5 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0015986249 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_6 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0019404373 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_7 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=5.5e-05 YPadPos=-0.0020236249 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_8 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.002174872 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_9 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001797404 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_10 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001419936 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_11 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001042468 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_12 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000145 YPadPos=-0.00093166667 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_13 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000145 YPadPos=-0.0011983333 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_14 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00083 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_15 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00049 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_16 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00049 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_17 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00083 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  launch_pad_LPPin [copper] = polyline(z=0, xy: (-0.0012, 5e-06) (-0.001322, 0.0001) (-0.001522, 0.0001) (-0.001522, -0.0001) (-0.001322, -0.0001) (-0.0012, -5e-06) (-0.00117, -5e-06) (-0.00117, 5e-06) (-0.0012, 5e-06), closed, covered)
  pocket_LPPin = polyline(z=0, xy: (-0.0012, 1.1e-05) (-0.001322, 0.0001765) (-0.0015985, 0.0001765) (-0.0015985, -0.0001765) (-0.001322, -0.0001765) (-0.0012, -1.1e-05) (-0.00117, -1.1e-05) (-0.00117, 1.1e-05) (-0.0012, 1.1e-05), closed, covered)
  launch_pad_LPPout [copper] = polyline(z=0, xy: (0.0012, -5e-06) (0.001322, -0.0001) (0.001522, -0.0001) (0.001522, 0.0001) (0.001322, 0.0001) (0.0012, 5e-06) (0.00117, 5e-06) (0.00117, -5e-06) (0.0012, -5e-06), closed, covered)
  pocket_LPPout = polyline(z=0, xy: (0.0012, -1.1e-05) (0.001322, -0.0001765) (0.0015985, -0.0001765) (0.0015985, 0.0001765) (0.001322, 0.0001765) (0.0012, 1.1e-05) (0.00117, 1.1e-05) (0.00117, -1.1e-05) (0.0012, -1.1e-05), closed, covered)
  tap_trace_n0_ch3 [copper] = polyline(z=0, xy: (-5e-06, -0.0001) (-5e-06, -5e-06) (-0.00015, -5e-06) (-0.00015, 5e-06) (0.00015, 5e-06) (0.00015, -5e-06) (5e-06, -5e-06) (5e-06, -0.0001) (-5e-06, -0.0001), closed, covered)
  tap_cut_n0_ch3 = polyline(z=0, xy: (-1.1e-05, -0.0001) (-1.1e-05, -1.1e-05) (-0.00015, -1.1e-05) (-0.00015, 1.1e-05) (0.00015, 1.1e-05) (0.00015, -1.1e-05) (1.1e-05, -1.1e-05) (1.1e-05, -0.0001) (-1.1e-05, -0.0001), closed, covered)
  plate_cp_ch3 [copper] = polyline(z=0, xy: (8.25e-05, -0.000295) (8.2461478e-05, -0.00029578414) (8.2346282e-05, -0.00029656072) (8.2155523e-05, -0.00029732228) (8.1891036e-05, -0.00029806147) (8.155537e-05, -0.00029877117) (8.1151757e-05, -0.00029944456) (8.0684084e-05, -0.00030007515) (8.0156854e-05, -0.00030065685) (7.9575146e-05, -0.00030118408) (7.8944562e-05, -0.00030165176) (7.8271174e-05, -0.00030205537) (7.7561467e-05, -0.00030239104) (7.6822277e-05, -0.00030265552) (7.6060723e-05, -0.00030284628) (7.5284137e-05, -0.00030296148) (7.45e-05, -0.000303) (-7.45e-05, -0.000303) (-7.5284137e-05, -0.00030296148) (-7.6060723e-05, -0.00030284628) (-7.6822277e-05, -0.00030265552) (-7.7561467e-05, -0.00030239104) (-7.8271174e-05, -0.00030205537) (-7.8944562e-05, -0.00030165176) (-7.9575146e-05, -0.00030118408) (-8.0156854e-05, -0.00030065685) (-8.0684084e-05, -0.00030007515) (-8.1151757e-05, -0.00029944456) (-8.155537e-05, -0.00029877117) (-8.1891036e-05, -0.00029806147) (-8.2155523e-05, -0.00029732228) (-8.2346282e-05, -0.00029656072) (-8.2461478e-05, -0.00029578414) (-8.25e-05, -0.000295) (-8.25e-05, -0.00027) (-8.2461478e-05, -0.00026921586) (-8.2346282e-05, -0.00026843928) (-8.2155523e-05, -0.00026767772) (-8.1891036e-05, -0.00026693853) (-8.155537e-05, -0.00026622883) (-8.1151757e-05, -0.00026555544) (-8.0684084e-05, -0.00026492485) (-8.0156854e-05, -0.00026434315) (-7.9575146e-05, -0.00026381592) (-7.8944562e-05, -0.00026334824) (-7.8271174e-05, -0.00026294463) (-7.7561467e-05, -0.00026260896) (-7.6822277e-05, -0.00026234448) (-7.6060723e-05, -0.00026215372) (-7.5284137e-05, -0.00026203852) (-7.45e-05, -0.000262) (7.45e-05, -0.000262) (7.5284137e-05, -0.00026203852) (7.6060723e-05, -0.00026215372) (7.6822277e-05, -0.00026234448) (7.7561467e-05, -0.00026260896) (7.8271174e-05, -0.00026294463) (7.8944562e-05, -0.00026334824) (7.9575146e-05, -0.00026381592) (8.0156854e-05, -0.00026434315) (8.0684084e-05, -0.00026492485) (8.1151757e-05, -0.00026555544) (8.155537e-05, -0.00026622883) (8.1891036e-05, -0.00026693853) (8.2155523e-05, -0.00026767772) (8.2346282e-05, -0.00026843928) (8.2461478e-05, -0.00026921586) (8.25e-05, -0.00027) (8.25e-05, -0.000295), closed, covered)
  frame_cp_ch3 [copper] = polyline(z=0, xy: (8.25e-05, -0.000311) (8.3284137e-05, -0.00031096148) (8.4060723e-05, -0.00031084628) (8.4822277e-05, -0.00031065552) (8.5561467e-05, -0.00031039104) (8.6271174e-05, -0.00031005537) (8.6944562e-05, -0.00030965176) (8.7575146e-05, -0.00030918408) (8.8156854e-05, -0.00030865685) (8.8684084e-05, -0.00030807515) (8.9151757e-05, -0.00030744456) (8.955537e-05, -0.00030677117) (8.9891036e-05, -0.00030606147) (9.0155523e-05, -0.00030532228) (9.0346282e-05, -0.00030456072) (9.0461478e-05, -0.00030378414) (9.05e-05, -0.000303) (9.05e-05, -0.000262) (9.0461478e-05, -0.00026121586) (9.0346282e-05, -0.00026043928) (9.0155523e-05, -0.00025967772) (8.9891036e-05, -0.00025893853) (8.955537e-05, -0.00025822883) (8.9151757e-05, -0.00025755544) (8.8684084e-05, -0.00025692485) (8.8156854e-05, -0.00025634315) (8.7575146e-05, -0.00025581592) (8.6944562e-05, -0.00025534824) (8.6271174e-05, -0.00025494463) (8.5561467e-05, -0.00025460896) (8.4822277e-05, -0.00025434448) (8.4060723e-05, -0.00025415372) (8.3284137e-05, -0.00025403852) (8.25e-05, -0.000254) (1.909818e-05, -0.000254) (1.8901939e-05, -0.00025399518) (1.8412015e-05, -0.00025397111) (1.80216e-05, -0.00025393266) (1.7633541e-05, -0.0002538751) (1.7248774e-05, -0.00025379856) (1.6868226e-05, -0.00025370324) (1.6492814e-05, -0.00025358936) (1.6123441e-05, -0.0002534572) (1.5760999e-05, -0.00025330707) (1.540636e-05, -0.00025313934) (1.5060378e-05, -0.00025295441) (1.4723887e-05, -0.00025275272) (1.4397697e-05, -0.00025253477) (1.4082595e-05, -0.00025230107) (1.3779339e-05, -0.0002520522) (1.348866e-05, -0.00025178874) (1.3211259e-05, -0.00025151134) (1.2947803e-05, -0.00025122066) (1.2698928e-05, -0.0002509174) (1.2465232e-05, -0.0002506023) (1.2247279e-05, -0.00025027611) (1.2045594e-05, -0.00024993962) (1.1860663e-05, -0.00024959364) (1.1692931e-05, -0.000249239) (1.1542802e-05, -0.00024887656) (1.1410639e-05, -0.00024850719) (1.1296759e-05, -0.00024813177) (1.1201436e-05, -0.00024775123) (1.1124902e-05, -0.00024736646) (1.1067338e-05, -0.0002469784) (1.1028886e-05, -0.00024658799) (1.1004817e-05, -0.00024609806) (1.1e-05, -0.00024590182) (1.1e-05, -0.00019809818) (1.1004817e-05, -0.00019790194) (1.1028886e-05, -0.00019741201) (1.1067338e-05, -0.0001970216) (1.1124902e-05, -0.00019663354) (1.1201436e-05, -0.00019624877) (1.1296759e-05, -0.00019586823) (1.1410639e-05, -0.00019549281) (1.1542802e-05, -0.00019512344) (1.1692931e-05, -0.000194761) (1.1860663e-05, -0.00019440636) (1.2045594e-05, -0.00019406038) (1.2247279e-05, -0.00019372389) (1.2465232e-05, -0.0001933977) (1.2698928e-05, -0.00019308259) (1.2947803e-05, -0.00019277934) (1.3211259e-05, -0.00019248866) (1.348866e-05, -0.00019221126) (1.3779339e-05, -0.0001919478) (1.4082595e-05, -0.00019169893) (1.4397697e-05, -0.00019146523) (1.4723887e-05, -0.00019124728) (1.5060378e-05, -0.00019104559) (1.540636e-05, -0.00019086066) (1.5760999e-05, -0.00019069293) (1.6123441e-05, -0.0001905428) (1.6492814e-05, -0.00019041064) (1.6868226e-05, -0.00019029676) (1.7248774e-05, -0.00019020144) (1.7633541e-05, -0.0001901249) (1.80216e-05, -0.00019006734) (1.8412015e-05, -0.00019002889) (1.8901939e-05, -0.00019000482) (1.909818e-05, -0.00019) (0.00013940182, -0.00019) (0.00013959806, -0.00019000482) (0.00014008798, -0.00019002889) (0.0001404784, -0.00019006734) (0.00014086646, -0.0001901249) (0.00014125123, -0.00019020144) (0.00014163177, -0.00019029676) (0.00014200719, -0.00019041064) (0.00014237656, -0.0001905428) (0.000142739, -0.00019069293) (0.00014309364, -0.00019086066) (0.00014343962, -0.00019104559) (0.00014377611, -0.00019124728) (0.0001441023, -0.00019146523) (0.0001444174, -0.00019169893) (0.00014472066, -0.0001919478) (0.00014501134, -0.00019221126) (0.00014528874, -0.00019248866) (0.0001455522, -0.00019277934) (0.00014580107, -0.00019308259) (0.00014603477, -0.0001933977) (0.00014625272, -0.00019372389) (0.00014645441, -0.00019406038) (0.00014663934, -0.00019440636) (0.00014680707, -0.000194761) (0.0001469572, -0.00019512344) (0.00014708936, -0.00019549281) (0.00014720324, -0.00019586823) (0.00014729856, -0.00019624877) (0.0001473751, -0.00019663354) (0.00014743266, -0.0001970216) (0.00014747111, -0.00019741201) (0.00014749518, -0.00019790194) (0.0001475, -0.00019809818) (0.0001475, -0.00035490182) (0.00014749518, -0.00035509806) (0.00014747111, -0.00035558799) (0.00014743266, -0.0003559784) (0.0001473751, -0.00035636646) (0.00014729856, -0.00035675123) (0.00014720324, -0.00035713177) (0.00014708936, -0.00035750719) (0.0001469572, -0.00035787656) (0.00014680707, -0.000358239) (0.00014663934, -0.00035859364) (0.00014645441, -0.00035893962) (0.00014625272, -0.00035927611) (0.00014603477, -0.0003596023) (0.00014580107, -0.00035991741) (0.0001455522, -0.00036022066) (0.00014528874, -0.00036051134) (0.00014501134, -0.00036078874) (0.00014472066, -0.0003610522) (0.0001444174, -0.00036130107) (0.0001441023, -0.00036153477) (0.00014377611, -0.00036175272) (0.00014343962, -0.00036195441) (0.00014309364, -0.00036213934) (0.000142739, -0.00036230707) (0.00014237656, -0.0003624572) (0.00014200719, -0.00036258936) (0.00014163177, -0.00036270324) (0.00014125123, -0.00036279856) (0.00014086646, -0.0003628751) (0.0001404784, -0.00036293266) (0.00014008798, -0.00036297111) (0.00013959806, -0.00036299518) (0.00013940182, -0.000363) (-0.00013940182, -0.000363) (-0.00013959806, -0.00036299518) (-0.00014008798, -0.00036297111) (-0.0001404784, -0.00036293266) (-0.00014086646, -0.0003628751) (-0.00014125123, -0.00036279856) (-0.00014163177, -0.00036270324) (-0.00014200719, -0.00036258936) (-0.00014237656, -0.0003624572) (-0.000142739, -0.00036230707) (-0.00014309364, -0.00036213934) (-0.00014343962, -0.00036195441) (-0.00014377611, -0.00036175272) (-0.0001441023, -0.00036153477) (-0.0001444174, -0.00036130107) (-0.00014472066, -0.0003610522) (-0.00014501134, -0.00036078874) (-0.00014528874, -0.00036051134) (-0.0001455522, -0.00036022066) (-0.00014580107, -0.00035991741) (-0.00014603477, -0.0003596023) (-0.00014625272, -0.00035927611) (-0.00014645441, -0.00035893962) (-0.00014663934, -0.00035859364) (-0.00014680707, -0.000358239) (-0.0001469572, -0.00035787656) (-0.00014708936, -0.00035750719) (-0.00014720324, -0.00035713177) (-0.00014729856, -0.00035675123) (-0.0001473751, -0.00035636646) (-0.00014743266, -0.0003559784) (-0.00014747111, -0.00035558799) (-0.00014749518, -0.00035509806) (-0.0001475, -0.00035490182) (-0.0001475, -0.00019809818) (-0.00014749518, -0.00019790194) (-0.00014747111, -0.00019741201) (-0.00014743266, -0.0001970216) (-0.0001473751, -0.00019663354) (-0.00014729856, -0.00019624877) (-0.00014720324, -0.00019586823) (-0.00014708936, -0.00019549281) (-0.0001469572, -0.00019512344) (-0.00014680707, -0.000194761) (-0.00014663934, -0.00019440636) (-0.00014645441, -0.00019406038) (-0.00014625272, -0.00019372389) (-0.00014603477, -0.0001933977) (-0.00014580107, -0.00019308259) (-0.0001455522, -0.00019277934) (-0.00014528874, -0.00019248866) (-0.00014501134, -0.00019221126) (-0.00014472066, -0.0001919478) (-0.0001444174, -0.00019169893) (-0.0001441023, -0.00019146523) (-0.00014377611, -0.00019124728) (-0.00014343962, -0.00019104559) (-0.00014309364, -0.00019086066) (-0.000142739, -0.00019069293) (-0.00014237656, -0.0001905428) (-0.00014200719, -0.00019041064) (-0.00014163177, -0.00019029676) (-0.00014125123, -0.00019020144) (-0.00014086646, -0.0001901249) (-0.0001404784, -0.00019006734) (-0.00014008798, -0.00019002889) (-0.00013959806, -0.00019000482) (-0.00013940182, -0.00019) (-1.909818e-05, -0.00019) (-1.8901939e-05, -0.00019000482) (-1.8412015e-05, -0.00019002889) (-1.80216e-05, -0.00019006734) (-1.7633541e-05, -0.0001901249) (-1.7248774e-05, -0.00019020144) (-1.6868226e-05, -0.00019029676) (-1.6492814e-05, -0.00019041064) (-1.6123441e-05, -0.0001905428) (-1.5760999e-05, -0.00019069293) (-1.540636e-05, -0.00019086066) (-1.5060378e-05, -0.00019104559) (-1.4723887e-05, -0.00019124728) (-1.4397697e-05, -0.00019146523) (-1.4082595e-05, -0.00019169893) (-1.3779339e-05, -0.0001919478) (-1.348866e-05, -0.00019221126) (-1.3211259e-05, -0.00019248866) (-1.2947803e-05, -0.00019277934) (-1.2698928e-05, -0.00019308259) (-1.2465232e-05, -0.0001933977) (-1.2247279e-05, -0.00019372389) (-1.2045594e-05, -0.00019406038) (-1.1860663e-05, -0.00019440636) (-1.1692931e-05, -0.000194761) (-1.1542802e-05, -0.00019512344) (-1.1410639e-05, -0.00019549281) (-1.1296759e-05, -0.00019586823) (-1.1201436e-05, -0.00019624877) (-1.1124902e-05, -0.00019663354) (-1.1067338e-05, -0.0001970216) (-1.1028886e-05, -0.00019741201) (-1.1004817e-05, -0.00019790194) (-1.1e-05, -0.00019809818) (-1.1e-05, -0.00024590182) (-1.1004817e-05, -0.00024609806) (-1.1028886e-05, -0.00024658799) (-1.1067338e-05, -0.0002469784) (-1.1124902e-05, -0.00024736646) (-1.1201436e-05, -0.00024775123) (-1.1296759e-05, -0.00024813177) (-1.1410639e-05, -0.00024850719) (-1.1542802e-05, -0.00024887656) (-1.1692931e-05, -0.000249239) (-1.1860663e-05, -0.00024959364) (-1.2045594e-05, -0.00024993962) (-1.2247279e-05, -0.00025027611) (-1.2465232e-05, -0.0002506023) (-1.2698928e-05, -0.0002509174) (-1.2947803e-05, -0.00025122066) (-1.3211259e-05, -0.00025151134) (-1.348866e-05, -0.00025178874) (-1.3779339e-05, -0.0002520522) (-1.4082595e-05, -0.00025230107) (-1.4397697e-05, -0.00025253477) (-1.4723887e-05, -0.00025275272) (-1.5060378e-05, -0.00025295441) (-1.540636e-05, -0.00025313934) (-1.5760999e-05, -0.00025330707) (-1.6123441e-05, -0.0002534572) (-1.6492814e-05, -0.00025358936) (-1.6868226e-05, -0.00025370324)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, closed, covered)
  pocket_cp_ch3 = polyline(z=0, xy: (0.0001475, -0.000375) (-0.0001475, -0.000375) (-0.00014867621, -0.00037494222) (-0.00014984108, -0.00037476942) (-0.00015098342, -0.00037448328) (-0.0001520922, -0.00037408655) (-0.00015315676, -0.00037358305) (-0.00015416684, -0.00037297763) (-0.00015511272, -0.00037227612) (-0.00015598528, -0.00037148528) (-0.00015677613, -0.00037061272) (-0.00015747764, -0.00036966684) (-0.00015808305, -0.00036865676) (-0.00015858655, -0.0003675922) (-0.00015898328, -0.00036648342) (-0.00015926942, -0.00036534108) (-0.00015944222, -0.00036417621) (-0.0001595, -0.000363) (-0.0001595, -0.00019) (-0.00015944222, -0.00018882379) (-0.00015926942, -0.00018765892) (-0.00015898328, -0.00018651658) (-0.00015858655, -0.0001854078) (-0.00015808305, -0.00018434324) (-0.00015747764, -0.00018333316) (-0.00015677613, -0.00018238728) (-0.00015598528, -0.00018151472) (-0.00015511272, -0.00018072388) (-0.00015416684, -0.00018002237) (-0.00015315676, -0.00017941694) (-0.0001520922, -0.00017891345) (-0.00015098342, -0.00017851672) (-0.00014984108, -0.00017823058) (-0.00014867621, -0.00017805778) (-0.0001475, -0.000178) (0.0001475, -0.000178) (0.00014867621, -0.00017805778) (0.00014984108, -0.00017823058) (0.00015098342, -0.00017851672) (0.0001520922, -0.00017891345) (0.00015315676, -0.00017941694) (0.00015416684, -0.00018002237) (0.00015511272, -0.00018072388) (0.00015598528, -0.00018151472) (0.00015677613, -0.00018238728) (0.00015747764, -0.00018333316) (0.00015808305, -0.00018434324) (0.00015858655, -0.0001854078) (0.00015898328, -0.00018651658) (0.00015926942, -0.00018765892) (0.00015944222, -0.00018882379) (0.0001595, -0.00019) (0.0001595, -0.000363) (0.00015944222, -0.00036417621) (0.00015926942, -0.00036534108) (0.00015898328, -0.00036648342) (0.00015858655, -0.0003675922) (0.00015808305, -0.00036865676) (0.00015747764, -0.00036966684) (0.00015677613, -0.00037061272) (0.00015598528, -0.00037148528) (0.00015511272, -0.00037227612) (0.00015416684, -0.00037297763) (0.00015315676, -0.00037358305) (0.0001520922, -0.00037408655) (0.00015098342, -0.00037448328) (0.00014984108, -0.00037476942) (0.00014867621, -0.00037494222) (0.0001475, -0.000375), closed, covered)
  tap_trace_jf_ch3 [copper] = polyline(z=0, xy: (5e-06, -0.001465) (5e-06, -0.00161) (3e-05, -0.00161) (3e-05, -0.00162) (5e-06, -0.00162) (5e-06, -0.001765) (-5e-06, -0.001765) (-5e-06, -0.001465) (5e-06, -0.001465), closed, covered)
  tap_cut_jf_ch3 = polyline(z=0, xy: (1.1e-05, -0.001465) (1.1e-05, -0.001604) (3e-05, -0.001604) (3e-05, -0.001626) (1.1e-05, -0.001626) (1.1e-05, -0.001765) (-1.1e-05, -0.001765) (-1.1e-05, -0.001465) (1.1e-05, -0.001465), closed, covered)
  tap_trace_jr_ch3 [copper] = polyline(z=0, xy: (0.00017, -0.00161) (0.000195, -0.00161) (0.000195, -0.001465) (0.000205, -0.001465) (0.000205, -0.001765) (0.000195, -0.001765) (0.000195, -0.00162) (0.00017, -0.00162) (0.00017, -0.00161), closed, covered)
  tap_cut_jr_ch3 = polyline(z=0, xy: (0.00017, -0.001604) (0.000189, -0.001604) (0.000189, -0.001465) (0.000211, -0.001465) (0.000211, -0.001765) (0.000189, -0.001765) (0.000189, -0.001626) (0.00017, -0.001626) (0.00017, -0.001604), closed, covered)
  head_a_cj_ch3 [copper] = polyline(z=0, xy: (6.2e-05, -0.0016475) (6.1803966e-05, -0.0016474904) (6.1609819e-05, -0.0016474616) (6.1419431e-05, -0.0016474139) (6.1234633e-05, -0.0016473478) (6.1057207e-05, -0.0016472638) (6.088886e-05, -0.0016471629) (6.0731213e-05, -0.001647046) (6.0585786e-05, -0.0016469142) (6.0453979e-05, -0.0016467688) (6.0337061e-05, -0.0016466111) (6.0236157e-05, -0.0016464428) (6.0152241e-05, -0.0016462654) (6.0086119e-05, -0.0016460806) (6.0038429e-05, -0.0016458902) (6.0009631e-05, -0.001645696) (6e-05, -0.0016455) (6e-05, -0.0015845) (6.0009631e-05, -0.001584304) (6.0038429e-05, -0.0015841098) (6.0086119e-05, -0.0015839194) (6.0152241e-05, -0.0015837346) (6.0236157e-05, -0.0015835572) (6.0337061e-05, -0.0015833889) (6.0453979e-05, -0.0015832312) (6.0585786e-05, -0.0015830858) (6.0731213e-05, -0.001582954) (6.088886e-05, -0.0015828371) (6.1057207e-05, -0.0015827362) (6.1234633e-05, -0.0015826522) (6.1419431e-05, -0.0015825861) (6.1609819e-05, -0.0015825384) (6.1803966e-05, -0.0015825096) (6.2e-05, -0.0015825) (8.3e-05, -0.0015825) (8.3196034e-05, -0.0015825096) (8.3390181e-05, -0.0015825384) (8.3580569e-05, -0.0015825861) (8.3765367e-05, -0.0015826522) (8.3942793e-05, -0.0015827362) (8.411114e-05, -0.0015828371) (8.4268787e-05, -0.001582954) (8.4414214e-05, -0.0015830858) (8.4546021e-05, -0.0015832312) (8.4662939e-05, -0.0015833889) (8.4763843e-05, -0.0015835572) (8.4847759e-05, -0.0015837346) (8.4913881e-05, -0.0015839194) (8.4961571e-05, -0.0015841098) (8.4990369e-05, -0.001584304) (8.5e-05, -0.0015845) (8.5e-05, -0.0016455) (8.4990369e-05, -0.001645696) (8.4961571e-05, -0.0016458902) (8.4913881e-05, -0.0016460806) (8.4847759e-05, -0.0016462654) (8.4763843e-05, -0.0016464428) (8.4662939e-05, -0.0016466111) (8.4546021e-05, -0.0016467688) (8.4414214e-05, -0.0016469142) (8.4268787e-05, -0.001647046) (8.411114e-05, -0.0016471629) (8.3942793e-05, -0.0016472638) (8.3765367e-05, -0.0016473478) (8.3580569e-05, -0.0016474139) (8.3390181e-05, -0.0016474616) (8.3196034e-05, -0.0016474904) (8.3e-05, -0.0016475) (6.2e-05, -0.0016475), closed, covered)
  head_b_cj_ch3 [copper] = polyline(z=0, xy: (0.000117, -0.0016475) (0.00011680397, -0.0016474904) (0.00011660982, -0.0016474616) (0.00011641943, -0.0016474139) (0.00011623463, -0.0016473478) (0.00011605721, -0.0016472638) (0.00011588886, -0.0016471629) (0.00011573121, -0.001647046) (0.00011558579, -0.0016469142) (0.00011545398, -0.0016467688) (0.00011533706, -0.0016466111) (0.00011523616, -0.0016464428) (0.00011515224, -0.0016462654) (0.00011508612, -0.0016460806) (0.00011503843, -0.0016458902) (0.00011500963, -0.001645696) (0.000115, -0.0016455) (0.000115, -0.0015845) (0.00011500963, -0.001584304) (0.00011503843, -0.0015841098) (0.00011508612, -0.0015839194) (0.00011515224, -0.0015837346) (0.00011523616, -0.0015835572) (0.00011533706, -0.0015833889) (0.00011545398, -0.0015832312) (0.00011558579, -0.0015830858) (0.00011573121, -0.001582954) (0.00011588886, -0.0015828371) (0.00011605721, -0.0015827362) (0.00011623463, -0.0015826522) (0.00011641943, -0.0015825861) (0.00011660982, -0.0015825384) (0.00011680397, -0.0015825096) (0.000117, -0.0015825) (0.000138, -0.0015825) (0.00013819603, -0.0015825096) (0.00013839018, -0.0015825384) (0.00013858057, -0.0015825861) (0.00013876537, -0.0015826522) (0.00013894279, -0.0015827362) (0.00013911114, -0.0015828371) (0.00013926879, -0.001582954) (0.00013941421, -0.0015830858) (0.00013954602, -0.0015832312) (0.00013966294, -0.0015833889) (0.00013976384, -0.0015835572) (0.00013984776, -0.0015837346) (0.00013991388, -0.0015839194) (0.00013996157, -0.0015841098) (0.00013999037, -0.001584304) (0.00014, -0.0015845) (0.00014, -0.0016455) (0.00013999037, -0.001645696) (0.00013996157, -0.0016458902) (0.00013991388, -0.0016460806) (0.00013984776, -0.0016462654) (0.00013976384, -0.0016464428) (0.00013966294, -0.0016466111) (0.00013954602, -0.0016467688) (0.00013941421, -0.0016469142) (0.00013926879, -0.001647046) (0.00013911114, -0.0016471629) (0.00013894279, -0.0016472638) (0.00013876537, -0.0016473478) (0.00013858057, -0.0016474139) (0.00013839018, -0.0016474616) (0.00013819603, -0.0016474904) (0.000138, -0.0016475) (0.000117, -0.0016475), closed, covered)
  pocket_cj_ch3 = polyline(z=0, xy: (4.6e-05, -0.0016635) (4.5803966e-05, -0.0016634904) (4.5609819e-05, -0.0016634616) (4.5419431e-05, -0.0016634139) (4.5234633e-05, -0.0016633478) (4.5057207e-05, -0.0016632638) (4.488886e-05, -0.0016631629) (4.4731213e-05, -0.001663046) (4.4585786e-05, -0.0016629142) (4.4453979e-05, -0.0016627688) (4.4337061e-05, -0.0016626111) (4.4236157e-05, -0.0016624428) (4.4152241e-05, -0.0016622654) (4.4086119e-05, -0.0016620806) (4.4038429e-05, -0.0016618902) (4.4009631e-05, -0.001661696) (4.4e-05, -0.0016615) (4.4e-05, -0.0015685) (4.4009631e-05, -0.001568304) (4.4038429e-05, -0.0015681098) (4.4086119e-05, -0.0015679194) (4.4152241e-05, -0.0015677346) (4.4236157e-05, -0.0015675572) (4.4337061e-05, -0.0015673889) (4.4453979e-05, -0.0015672312) (4.4585786e-05, -0.0015670858) (4.4731213e-05, -0.001566954) (4.488886e-05, -0.0015668371) (4.5057207e-05, -0.0015667362) (4.5234633e-05, -0.0015666522) (4.5419431e-05, -0.0015665861) (4.5609819e-05, -0.0015665384) (4.5803966e-05, -0.0015665096) (4.6e-05, -0.0015665) (0.000154, -0.0015665) (0.00015419603, -0.0015665096) (0.00015439018, -0.0015665384) (0.00015458057, -0.0015665861) (0.00015476537, -0.0015666522) (0.00015494279, -0.0015667362) (0.00015511114, -0.0015668371) (0.00015526879, -0.001566954) (0.00015541421, -0.0015670858) (0.00015554602, -0.0015672312) (0.00015566294, -0.0015673889) (0.00015576384, -0.0015675572) (0.00015584776, -0.0015677346) (0.00015591388, -0.0015679194) (0.00015596157, -0.0015681098) (0.00015599037, -0.001568304) (0.000156, -0.0015685) (0.000156, -0.0016615) (0.00015599037, -0.001661696) (0.00015596157, -0.0016618902) (0.00015591388, -0.0016620806) (0.00015584776, -0.0016622654) (0.00015576384, -0.0016624428) (0.00015566294, -0.0016626111) (0.00015554602, -0.0016627688) (0.00015541421, -0.0016629142) (0.00015526879, -0.001663046) (0.00015511114, -0.0016631629) (0.00015494279, -0.0016632638) (0.00015476537, -0.0016633478) (0.00015458057, -0.0016634139) (0.00015439018, -0.0016634616) (0.00015419603, -0.0016634904) (0.000154, -0.0016635) (4.6e-05, -0.0016635), closed, covered)
  endcap_filt_ch3_start = rectangle(corner=(-0.000311, -0.000915, 0), x_size=2.2e-05, y_size=6e-06)
  endcap_res_ch3_start = rectangle(corner=(0.000539, -0.00255834, 0), x_size=2.2e-05, y_size=6e-06)
  endcap_res_a_ch3_start = rectangle(corner=(0.000189, -0.002921, 0), x_size=2.2e-05, y_size=6e-06)
  ground_main_plane [copper] = rectangle(corner=(-0.0017985, -0.003115, 0), x_size=0.003597, y_size=0.0034915)
  main [silicon] = box(corner=(-0.0017985, -0.003115, -0.000525), size=(0.003597, 0.0034915, 0.000525))
  ground_main_plane.subtract(cut_feed_in, lead_b_sub_cp_ch3, cut_feed_jf_ch3, pocket_cj_ch3, tap_cut_n0_ch3, lead_a_sub_cp_ch3, endcap_filt_ch3_start, pocket_cp_ch3, pocket_LPPout, cut_stub_p_ch3, tap_cut_jf_ch3, endcap_res_a_ch3_start, cut_res_a_ch3, cut_stub_f_ch3, tap_cut_jr_ch3, cut_res_ch3, pocket_LPPin, lead_b_sub_cj_ch3, endcap_res_ch3_start, lead_a_sub_cj_ch3, cut_feed_out, cut_filt_ch3, cut_stub_r_ch3)
boundaries and excitations:
  ThinCond1: ThinConductor Objects=[lead_a_cp_ch3, lead_b_cp_ch3, trace_stub_p_ch3, trace_feed_jf_ch3, lead_a_cj_ch3, lead_b_cj_ch3, trace_stub_f_ch3, trace_stub_r_ch3, trace_res_a_ch3, trace_filt_ch3, trace_res_ch3, trace_feed_in, trace_feed_out, launch_pad_LPPin, launch_pad_LPPout, tap_trace_n0_ch3, plate_cp_ch3, frame_cp_ch3, tap_trace_jf_ch3, tap_trace_jr_ch3, head_a_cj_ch3, head_b_cj_ch3, ground_main_plane] Material=pec Thickness=200nm
  frame_cp_ch3: SignalNet Objects=[lead_a_cp_ch3, trace_feed_jf_ch3, lead_a_cj_ch3, trace_stub_f_ch3, trace_filt_ch3, frame_cp_ch3, tap_trace_jf_ch3, head_a_cj_ch3]
  launch_pad_LPPin: SignalNet Objects=[lead_b_cp_ch3, trace_stub_p_ch3, trace_feed_in, trace_feed_out, launch_pad_LPPin, launch_pad_LPPout, tap_trace_n0_ch3, plate_cp_ch3]
  head_b_cj_ch3: SignalNet Objects=[lead_b_cj_ch3, trace_stub_r_ch3, trace_res_a_ch3, trace_res_ch3, tap_trace_jr_ch3, head_b_cj_ch3]
  g_wb: SignalNet Objects=[g_wb, g_wb_1..g_wb_17, ground_main_plane]
setups:
  Setup: Matrix AdaptiveFreq=6.7GHz Cap{MaxPass=15 MinPass=2 MinConvPass=2 PerError=0.3 PerRefine=30 AutoIncreaseSolutionOrder SolutionOrder=Normal Solver_Type=Iterative}
source amplitudes:
  frame_cp_ch3: Cap 1V 0deg
  g_wb, head_b_cj_ch3, launch_pad_LPPin: Cap 0V 0deg

design q3d6_full_2101_q3d (Q3D Extractor, model units mm)
options: SParamCalcMethod=EqTransLine Calculate_Lossy_Dielectrics
geometry:
  lead_a_cp_ch3_path = polyline((0, -0.000362999, 0) (0, -0.000415, 0))
  lead_a_cp_ch3 [copper] = polyline((5e-06, -0.000362999, 0) (-5e-06, -0.000362999, 0))
  lead_a_cp_ch3.sweep_along_path(lead_a_cp_ch3_path)
  lead_a_sub_cp_ch3_path = polyline((0, -0.000362999, 0) (0, -0.000415, 0))
  lead_a_sub_cp_ch3 = polyline((1.1e-05, -0.000362999, 0) (-1.1e-05, -0.000362999, 0))
  lead_a_sub_cp_ch3.sweep_along_path(lead_a_sub_cp_ch3_path)
  lead_b_cp_ch3_path = polyline((0, -0.000262001, 0) (0, -0.00015, 0))
  lead_b_cp_ch3 [copper] = polyline((-5e-06, -0.000262001, 0) (5e-06, -0.000262001, 0))
  lead_b_cp_ch3.sweep_along_path(lead_b_cp_ch3_path)
  lead_b_sub_cp_ch3_path = polyline((0, -0.000262001, 0) (0, -0.00015, 0))
  lead_b_sub_cp_ch3 = polyline((-1.1e-05, -0.000262001, 0) (1.1e-05, -0.000262001, 0))
  lead_b_sub_cp_ch3.sweep_along_path(lead_b_sub_cp_ch3_path)
  trace_stub_p_ch3_path = polyline((0, -0.0001, 0) (0, -0.00015, 0))
  trace_stub_p_ch3 [copper] = polyline((5e-06, -0.0001, 0) (-5e-06, -0.0001, 0))
  trace_stub_p_ch3.sweep_along_path(trace_stub_p_ch3_path)
  cut_stub_p_ch3_path = polyline((0, -0.0001, 0) (0, -0.00015, 0))
  cut_stub_p_ch3 = polyline((1.1e-05, -0.0001, 0) (-1.1e-05, -0.0001, 0))
  cut_stub_p_ch3.sweep_along_path(cut_stub_p_ch3_path)
  trace_feed_jf_ch3_path = polyline((0, -0.000415, 0) (0, -0.001465, 0))
  trace_feed_jf_ch3 [copper] = polyline((5e-06, -0.000415, 0) (-5e-06, -0.000415, 0))
  trace_feed_jf_ch3.sweep_along_path(trace_feed_jf_ch3_path)
  cut_feed_jf_ch3_path = polyline((0, -0.000415, 0) (0, -0.001465, 0))
  cut_feed_jf_ch3 = polyline((1.1e-05, -0.000415, 0) (-1.1e-05, -0.000415, 0))
  cut_feed_jf_ch3.sweep_along_path(cut_feed_jf_ch3_path)
  lead_a_cj_ch3_path = polyline((5.5001e-05, -0.001615, 0) (4.5e-05, -0.001615, 0))
  lead_a_cj_ch3 [copper] = polyline((5.5001e-05, -0.00162, 0) (5.5001e-05, -0.00161, 0))
  lead_a_cj_ch3.sweep_along_path(lead_a_cj_ch3_path)
  lead_a_sub_cj_ch3_path = polyline((5.5001e-05, -0.001615, 0) (4.5e-05, -0.001615, 0))
  lead_a_sub_cj_ch3 = polyline((5.5001e-05, -0.001626, 0) (5.5001e-05, -0.001604, 0))
  lead_a_sub_cj_ch3.sweep_along_path(lead_a_sub_cj_ch3_path)
  lead_b_cj_ch3_path = polyline((0.000144999, -0.001615, 0) (0.000155, -0.001615, 0))
  lead_b_cj_ch3 [copper] = polyline((0.000144999, -0.00161, 0) (0.000144999, -0.00162, 0))
  lead_b_cj_ch3.sweep_along_path(lead_b_cj_ch3_path)
  lead_b_sub_cj_ch3_path = polyline((0.000144999, -0.001615, 0) (0.000155, -0.001615, 0))
  lead_b_sub_cj_ch3 = polyline((0.000144999, -0.001604, 0) (0.000144999, -0.001626, 0))
  lead_b_sub_cj_ch3.sweep_along_path(lead_b_sub_cj_ch3_path)
  trace_stub_f_ch3_path = polyline((2.5e-05, -0.001615, 0) (4.5e-05, -0.001615, 0))
  trace_stub_f_ch3 [copper] = polyline((2.5e-05, -0.00161, 0) (2.5e-05, -0.00162, 0))
  trace_stub_f_ch3.sweep_along_path(trace_stub_f_ch3_path)
  cut_stub_f_ch3_path = polyline((2.5e-05, -0.001615, 0) (4.5e-05, -0.001615, 0))
  cut_stub_f_ch3 = polyline((2.5e-05, -0.001604, 0) (2.5e-05, -0.001626, 0))
  cut_stub_f_ch3.sweep_along_path(cut_stub_f_ch3_path)
  trace_stub_r_ch3_path = polyline((0.000175, -0.001615, 0) (0.000155, -0.001615, 0))
  trace_stub_r_ch3 [copper] = polyline((0.000175, -0.00162, 0) (0.000175, -0.00161, 0))
  trace_stub_r_ch3.sweep_along_path(trace_stub_r_ch3_path)
  cut_stub_r_ch3_path = polyline((0.000175, -0.001615, 0) (0.000155, -0.001615, 0))
  cut_stub_r_ch3 = polyline((0.000175, -0.001626, 0) (0.000175, -0.001604, 0))
  cut_stub_r_ch3.sweep_along_path(cut_stub_r_ch3_path)
  trace_res_a_ch3_path = polyline((0.0002, -0.002915, 0) (0.0002, -0.001765, 0))
  trace_res_a_ch3 [copper] = polyline((0.000195, -0.002915, 0) (0.000205, -0.002915, 0))
  trace_res_a_ch3.sweep_along_path(trace_res_a_ch3_path)
  cut_res_a_ch3_path = polyline((0.0002, -0.002915, 0) (0.0002, -0.001765, 0))
  cut_res_a_ch3 = polyline((0.000189, -0.002915, 0) (0.000211, -0.002915, 0))
  cut_res_a_ch3.sweep_along_path(cut_res_a_ch3_path)
  trace_filt_ch3_path = polyline(z=0, xy: (-0.0003, -0.000915) (-0.0003, -0.0022822498) (0, -0.0022822498) (0, -0.001765))
  trace_filt_ch3_path.fillet(Vertices=trace_filt_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  trace_filt_ch3 [copper] = polyline((-0.000295, -0.000915, 0) (-0.000305, -0.000915, 0))
  trace_filt_ch3.sweep_along_path(trace_filt_ch3_path)
  cut_filt_ch3_path = polyline(z=0, xy: (-0.0003, -0.000915) (-0.0003, -0.0022822498) (0, -0.0022822498) (0, -0.001765))
  cut_filt_ch3_path.fillet(Vertices=cut_filt_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  cut_filt_ch3 = polyline((-0.000289, -0.000915, 0) (-0.000311, -0.000915, 0))
  cut_filt_ch3.sweep_along_path(cut_filt_ch3_path)
  trace_res_ch3_path = polyline(z=0, xy: (0.00055, -0.00255234) (0.00055, -0.000665) (0.0002, -0.000665) (0.0002, -0.001465))
  trace_res_ch3_path.fillet(Vertices=trace_res_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  trace_res_ch3 [copper] = polyline((0.000545, -0.00255234, 0) (0.000555, -0.00255234, 0))
  trace_res_ch3.sweep_along_path(trace_res_ch3_path)
  cut_res_ch3_path = polyline(z=0, xy: (0.00055, -0.00255234) (0.00055, -0.000665) (0.0002, -0.000665) (0.0002, -0.001465))
  cut_res_ch3_path.fillet(Vertices=cut_res_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  cut_res_ch3 = polyline((0.000539, -0.00255234, 0) (0.000561, -0.00255234, 0))
  cut_res_ch3.sweep_along_path(cut_res_ch3_path)
  trace_feed_in_path = polyline((-0.00117, 0, 0) (-0.00015, 0, 0))
  trace_feed_in [copper] = polyline((-0.00117, 5e-06, 0) (-0.00117, -5e-06, 0))
  trace_feed_in.sweep_along_path(trace_feed_in_path)
  cut_feed_in_path = polyline((-0.00117, 0, 0) (-0.00015, 0, 0))
  cut_feed_in = polyline((-0.00117, 1.1e-05, 0) (-0.00117, -1.1e-05, 0))
  cut_feed_in.sweep_along_path(cut_feed_in_path)
  trace_feed_out_path = polyline((0.00015, 0, 0) (0.00117, 0, 0))
  trace_feed_out [copper] = polyline((0.00015, 5e-06, 0) (0.00015, -5e-06, 0))
  trace_feed_out.sweep_along_path(trace_feed_out_path)
  cut_feed_out_path = polyline((0.00015, 0, 0) (0.00117, 0, 0))
  cut_feed_out = polyline((0.00015, 1.1e-05, 0) (0.00015, -1.1e-05, 0))
  cut_feed_out.sweep_along_path(cut_feed_out_path)
  g_wb [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-5.5e-05 YPadPos=-0.000765 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_1 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-5.5e-05 YPadPos=-0.001115 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_2 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000255 YPadPos=-0.0025316667 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_3 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000255 YPadPos=-0.0021483333 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_4 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0012568124 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_5 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0015986249 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_6 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0019404373 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_7 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=5.5e-05 YPadPos=-0.0020236249 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_8 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.002174872 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_9 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001797404 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_10 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001419936 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_11 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001042468 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_12 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000145 YPadPos=-0.00093166667 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_13 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000145 YPadPos=-0.0011983333 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_14 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00083 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_15 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00049 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_16 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00049 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_17 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00083 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  launch_pad_LPPin [copper] = polyline(z=0, xy: (-0.0012, 5e-06) (-0.001322, 0.0001) (-0.001522, 0.0001) (-0.001522, -0.0001) (-0.001322, -0.0001) (-0.0012, -5e-06) (-0.00117, -5e-06) (-0.00117, 5e-06) (-0.0012, 5e-06), closed, covered)
  pocket_LPPin = polyline(z=0, xy: (-0.0012, 1.1e-05) (-0.001322, 0.0001765) (-0.0015985, 0.0001765) (-0.0015985, -0.0001765) (-0.001322, -0.0001765) (-0.0012, -1.1e-05) (-0.00117, -1.1e-05) (-0.00117, 1.1e-05) (-0.0012, 1.1e-05), closed, covered)
  launch_pad_LPPout [copper] = polyline(z=0, xy: (0.0012, -5e-06) (0.001322, -0.0001) (0.001522, -0.0001) (0.001522, 0.0001) (0.001322, 0.0001) (0.0012, 5e-06) (0.00117, 5e-06) (0.00117, -5e-06) (0.0012, -5e-06), closed, covered)
  pocket_LPPout = polyline(z=0, xy: (0.0012, -1.1e-05) (0.001322, -0.0001765) (0.0015985, -0.0001765) (0.0015985, 0.0001765) (0.001322, 0.0001765) (0.0012, 1.1e-05) (0.00117, 1.1e-05) (0.00117, -1.1e-05) (0.0012, -1.1e-05), closed, covered)
  tap_trace_n0_ch3 [copper] = polyline(z=0, xy: (-5e-06, -0.0001) (-5e-06, -5e-06) (-0.00015, -5e-06) (-0.00015, 5e-06) (0.00015, 5e-06) (0.00015, -5e-06) (5e-06, -5e-06) (5e-06, -0.0001) (-5e-06, -0.0001), closed, covered)
  tap_cut_n0_ch3 = polyline(z=0, xy: (-1.1e-05, -0.0001) (-1.1e-05, -1.1e-05) (-0.00015, -1.1e-05) (-0.00015, 1.1e-05) (0.00015, 1.1e-05) (0.00015, -1.1e-05) (1.1e-05, -1.1e-05) (1.1e-05, -0.0001) (-1.1e-05, -0.0001), closed, covered)
  plate_cp_ch3 [copper] = polyline(z=0, xy: (8.25e-05, -0.000295) (8.2461478e-05, -0.00029578414) (8.2346282e-05, -0.00029656072) (8.2155523e-05, -0.00029732228) (8.1891036e-05, -0.00029806147) (8.155537e-05, -0.00029877117) (8.1151757e-05, -0.00029944456) (8.0684084e-05, -0.00030007515) (8.0156854e-05, -0.00030065685) (7.9575146e-05, -0.00030118408) (7.8944562e-05, -0.00030165176) (7.8271174e-05, -0.00030205537) (7.7561467e-05, -0.00030239104) (7.6822277e-05, -0.00030265552) (7.6060723e-05, -0.00030284628) (7.5284137e-05, -0.00030296148) (7.45e-05, -0.000303) (-7.45e-05, -0.000303) (-7.5284137e-05, -0.00030296148) (-7.6060723e-05, -0.00030284628) (-7.6822277e-05, -0.00030265552) (-7.7561467e-05, -0.00030239104) (-7.8271174e-05, -0.00030205537) (-7.8944562e-05, -0.00030165176) (-7.9575146e-05, -0.00030118408) (-8.0156854e-05, -0.00030065685) (-8.0684084e-05, -0.00030007515) (-8.1151757e-05, -0.00029944456) (-8.155537e-05, -0.00029877117) (-8.1891036e-05, -0.00029806147) (-8.2155523e-05, -0.00029732228) (-8.2346282e-05, -0.00029656072) (-8.2461478e-05, -0.00029578414) (-8.25e-05, -0.000295) (-8.25e-05, -0.00027) (-8.2461478e-05, -0.00026921586) (-8.2346282e-05, -0.00026843928) (-8.2155523e-05, -0.00026767772) (-8.1891036e-05, -0.00026693853) (-8.155537e-05, -0.00026622883) (-8.1151757e-05, -0.00026555544) (-8.0684084e-05, -0.00026492485) (-8.0156854e-05, -0.00026434315) (-7.9575146e-05, -0.00026381592) (-7.8944562e-05, -0.00026334824) (-7.8271174e-05, -0.00026294463) (-7.7561467e-05, -0.00026260896) (-7.6822277e-05, -0.00026234448) (-7.6060723e-05, -0.00026215372) (-7.5284137e-05, -0.00026203852) (-7.45e-05, -0.000262) (7.45e-05, -0.000262) (7.5284137e-05, -0.00026203852) (7.6060723e-05, -0.00026215372) (7.6822277e-05, -0.00026234448) (7.7561467e-05, -0.00026260896) (7.8271174e-05, -0.00026294463) (7.8944562e-05, -0.00026334824) (7.9575146e-05, -0.00026381592) (8.0156854e-05, -0.00026434315) (8.0684084e-05, -0.00026492485) (8.1151757e-05, -0.00026555544) (8.155537e-05, -0.00026622883) (8.1891036e-05, -0.00026693853) (8.2155523e-05, -0.00026767772) (8.2346282e-05, -0.00026843928) (8.2461478e-05, -0.00026921586) (8.25e-05, -0.00027) (8.25e-05, -0.000295), closed, covered)
  frame_cp_ch3 [copper] = polyline(z=0, xy: (8.25e-05, -0.000311) (8.3284137e-05, -0.00031096148) (8.4060723e-05, -0.00031084628) (8.4822277e-05, -0.00031065552) (8.5561467e-05, -0.00031039104) (8.6271174e-05, -0.00031005537) (8.6944562e-05, -0.00030965176) (8.7575146e-05, -0.00030918408) (8.8156854e-05, -0.00030865685) (8.8684084e-05, -0.00030807515) (8.9151757e-05, -0.00030744456) (8.955537e-05, -0.00030677117) (8.9891036e-05, -0.00030606147) (9.0155523e-05, -0.00030532228) (9.0346282e-05, -0.00030456072) (9.0461478e-05, -0.00030378414) (9.05e-05, -0.000303) (9.05e-05, -0.000262) (9.0461478e-05, -0.00026121586) (9.0346282e-05, -0.00026043928) (9.0155523e-05, -0.00025967772) (8.9891036e-05, -0.00025893853) (8.955537e-05, -0.00025822883) (8.9151757e-05, -0.00025755544) (8.8684084e-05, -0.00025692485) (8.8156854e-05, -0.00025634315) (8.7575146e-05, -0.00025581592) (8.6944562e-05, -0.00025534824) (8.6271174e-05, -0.00025494463) (8.5561467e-05, -0.00025460896) (8.4822277e-05, -0.00025434448) (8.4060723e-05, -0.00025415372) (8.3284137e-05, -0.00025403852) (8.25e-05, -0.000254) (1.909818e-05, -0.000254) (1.8901939e-05, -0.00025399518) (1.8412015e-05, -0.00025397111) (1.80216e-05, -0.00025393266) (1.7633541e-05, -0.0002538751) (1.7248774e-05, -0.00025379856) (1.6868226e-05, -0.00025370324) (1.6492814e-05, -0.00025358936) (1.6123441e-05, -0.0002534572) (1.5760999e-05, -0.00025330707) (1.540636e-05, -0.00025313934) (1.5060378e-05, -0.00025295441) (1.4723887e-05, -0.00025275272) (1.4397697e-05, -0.00025253477) (1.4082595e-05, -0.00025230107) (1.3779339e-05, -0.0002520522) (1.348866e-05, -0.00025178874) (1.3211259e-05, -0.00025151134) (1.2947803e-05, -0.00025122066) (1.2698928e-05, -0.0002509174) (1.2465232e-05, -0.0002506023) (1.2247279e-05, -0.00025027611) (1.2045594e-05, -0.00024993962) (1.1860663e-05, -0.00024959364) (1.1692931e-05, -0.000249239) (1.1542802e-05, -0.00024887656) (1.1410639e-05, -0.00024850719) (1.1296759e-05, -0.00024813177) (1.1201436e-05, -0.00024775123) (1.1124902e-05, -0.00024736646) (1.1067338e-05, -0.0002469784) (1.1028886e-05, -0.00024658799) (1.1004817e-05, -0.00024609806) (1.1e-05, -0.00024590182) (1.1e-05, -0.00019809818) (1.1004817e-05, -0.00019790194) (1.1028886e-05, -0.00019741201) (1.1067338e-05, -0.0001970216) (1.1124902e-05, -0.00019663354) (1.1201436e-05, -0.00019624877) (1.1296759e-05, -0.00019586823) (1.1410639e-05, -0.00019549281) (1.1542802e-05, -0.00019512344) (1.1692931e-05, -0.000194761) (1.1860663e-05, -0.00019440636) (1.2045594e-05, -0.00019406038) (1.2247279e-05, -0.00019372389) (1.2465232e-05, -0.0001933977) (1.2698928e-05, -0.00019308259) (1.2947803e-05, -0.00019277934) (1.3211259e-05, -0.00019248866) (1.348866e-05, -0.00019221126) (1.3779339e-05, -0.0001919478) (1.4082595e-05, -0.00019169893) (1.4397697e-05, -0.00019146523) (1.4723887e-05, -0.00019124728) (1.5060378e-05, -0.00019104559) (1.540636e-05, -0.00019086066) (1.5760999e-05, -0.00019069293) (1.6123441e-05, -0.0001905428) (1.6492814e-05, -0.00019041064) (1.6868226e-05, -0.00019029676) (1.7248774e-05, -0.00019020144) (1.7633541e-05, -0.0001901249) (1.80216e-05, -0.00019006734) (1.8412015e-05, -0.00019002889) (1.8901939e-05, -0.00019000482) (1.909818e-05, -0.00019) (0.00013940182, -0.00019) (0.00013959806, -0.00019000482) (0.00014008798, -0.00019002889) (0.0001404784, -0.00019006734) (0.00014086646, -0.0001901249) (0.00014125123, -0.00019020144) (0.00014163177, -0.00019029676) (0.00014200719, -0.00019041064) (0.00014237656, -0.0001905428) (0.000142739, -0.00019069293) (0.00014309364, -0.00019086066) (0.00014343962, -0.00019104559) (0.00014377611, -0.00019124728) (0.0001441023, -0.00019146523) (0.0001444174, -0.00019169893) (0.00014472066, -0.0001919478) (0.00014501134, -0.00019221126) (0.00014528874, -0.00019248866) (0.0001455522, -0.00019277934) (0.00014580107, -0.00019308259) (0.00014603477, -0.0001933977) (0.00014625272, -0.00019372389) (0.00014645441, -0.00019406038) (0.00014663934, -0.00019440636) (0.00014680707, -0.000194761) (0.0001469572, -0.00019512344) (0.00014708936, -0.00019549281) (0.00014720324, -0.00019586823) (0.00014729856, -0.00019624877) (0.0001473751, -0.00019663354) (0.00014743266, -0.0001970216) (0.00014747111, -0.00019741201) (0.00014749518, -0.00019790194) (0.0001475, -0.00019809818) (0.0001475, -0.00035490182) (0.00014749518, -0.00035509806) (0.00014747111, -0.00035558799) (0.00014743266, -0.0003559784) (0.0001473751, -0.00035636646) (0.00014729856, -0.00035675123) (0.00014720324, -0.00035713177) (0.00014708936, -0.00035750719) (0.0001469572, -0.00035787656) (0.00014680707, -0.000358239) (0.00014663934, -0.00035859364) (0.00014645441, -0.00035893962) (0.00014625272, -0.00035927611) (0.00014603477, -0.0003596023) (0.00014580107, -0.00035991741) (0.0001455522, -0.00036022066) (0.00014528874, -0.00036051134) (0.00014501134, -0.00036078874) (0.00014472066, -0.0003610522) (0.0001444174, -0.00036130107) (0.0001441023, -0.00036153477) (0.00014377611, -0.00036175272) (0.00014343962, -0.00036195441) (0.00014309364, -0.00036213934) (0.000142739, -0.00036230707) (0.00014237656, -0.0003624572) (0.00014200719, -0.00036258936) (0.00014163177, -0.00036270324) (0.00014125123, -0.00036279856) (0.00014086646, -0.0003628751) (0.0001404784, -0.00036293266) (0.00014008798, -0.00036297111) (0.00013959806, -0.00036299518) (0.00013940182, -0.000363) (-0.00013940182, -0.000363) (-0.00013959806, -0.00036299518) (-0.00014008798, -0.00036297111) (-0.0001404784, -0.00036293266) (-0.00014086646, -0.0003628751) (-0.00014125123, -0.00036279856) (-0.00014163177, -0.00036270324) (-0.00014200719, -0.00036258936) (-0.00014237656, -0.0003624572) (-0.000142739, -0.00036230707) (-0.00014309364, -0.00036213934) (-0.00014343962, -0.00036195441) (-0.00014377611, -0.00036175272) (-0.0001441023, -0.00036153477) (-0.0001444174, -0.00036130107) (-0.00014472066, -0.0003610522) (-0.00014501134, -0.00036078874) (-0.00014528874, -0.00036051134) (-0.0001455522, -0.00036022066) (-0.00014580107, -0.00035991741) (-0.00014603477, -0.0003596023) (-0.00014625272, -0.00035927611) (-0.00014645441, -0.00035893962) (-0.00014663934, -0.00035859364) (-0.00014680707, -0.000358239) (-0.0001469572, -0.00035787656) (-0.00014708936, -0.00035750719) (-0.00014720324, -0.00035713177) (-0.00014729856, -0.00035675123) (-0.0001473751, -0.00035636646) (-0.00014743266, -0.0003559784) (-0.00014747111, -0.00035558799) (-0.00014749518, -0.00035509806) (-0.0001475, -0.00035490182) (-0.0001475, -0.00019809818) (-0.00014749518, -0.00019790194) (-0.00014747111, -0.00019741201) (-0.00014743266, -0.0001970216) (-0.0001473751, -0.00019663354) (-0.00014729856, -0.00019624877) (-0.00014720324, -0.00019586823) (-0.00014708936, -0.00019549281) (-0.0001469572, -0.00019512344) (-0.00014680707, -0.000194761) (-0.00014663934, -0.00019440636) (-0.00014645441, -0.00019406038) (-0.00014625272, -0.00019372389) (-0.00014603477, -0.0001933977) (-0.00014580107, -0.00019308259) (-0.0001455522, -0.00019277934) (-0.00014528874, -0.00019248866) (-0.00014501134, -0.00019221126) (-0.00014472066, -0.0001919478) (-0.0001444174, -0.00019169893) (-0.0001441023, -0.00019146523) (-0.00014377611, -0.00019124728) (-0.00014343962, -0.00019104559) (-0.00014309364, -0.00019086066) (-0.000142739, -0.00019069293) (-0.00014237656, -0.0001905428) (-0.00014200719, -0.00019041064) (-0.00014163177, -0.00019029676) (-0.00014125123, -0.00019020144) (-0.00014086646, -0.0001901249) (-0.0001404784, -0.00019006734) (-0.00014008798, -0.00019002889) (-0.00013959806, -0.00019000482) (-0.00013940182, -0.00019) (-1.909818e-05, -0.00019) (-1.8901939e-05, -0.00019000482) (-1.8412015e-05, -0.00019002889) (-1.80216e-05, -0.00019006734) (-1.7633541e-05, -0.0001901249) (-1.7248774e-05, -0.00019020144) (-1.6868226e-05, -0.00019029676) (-1.6492814e-05, -0.00019041064) (-1.6123441e-05, -0.0001905428) (-1.5760999e-05, -0.00019069293) (-1.540636e-05, -0.00019086066) (-1.5060378e-05, -0.00019104559) (-1.4723887e-05, -0.00019124728) (-1.4397697e-05, -0.00019146523) (-1.4082595e-05, -0.00019169893) (-1.3779339e-05, -0.0001919478) (-1.348866e-05, -0.00019221126) (-1.3211259e-05, -0.00019248866) (-1.2947803e-05, -0.00019277934) (-1.2698928e-05, -0.00019308259) (-1.2465232e-05, -0.0001933977) (-1.2247279e-05, -0.00019372389) (-1.2045594e-05, -0.00019406038) (-1.1860663e-05, -0.00019440636) (-1.1692931e-05, -0.000194761) (-1.1542802e-05, -0.00019512344) (-1.1410639e-05, -0.00019549281) (-1.1296759e-05, -0.00019586823) (-1.1201436e-05, -0.00019624877) (-1.1124902e-05, -0.00019663354) (-1.1067338e-05, -0.0001970216) (-1.1028886e-05, -0.00019741201) (-1.1004817e-05, -0.00019790194) (-1.1e-05, -0.00019809818) (-1.1e-05, -0.00024590182) (-1.1004817e-05, -0.00024609806) (-1.1028886e-05, -0.00024658799) (-1.1067338e-05, -0.0002469784) (-1.1124902e-05, -0.00024736646) (-1.1201436e-05, -0.00024775123) (-1.1296759e-05, -0.00024813177) (-1.1410639e-05, -0.00024850719) (-1.1542802e-05, -0.00024887656) (-1.1692931e-05, -0.000249239) (-1.1860663e-05, -0.00024959364) (-1.2045594e-05, -0.00024993962) (-1.2247279e-05, -0.00025027611) (-1.2465232e-05, -0.0002506023) (-1.2698928e-05, -0.0002509174) (-1.2947803e-05, -0.00025122066) (-1.3211259e-05, -0.00025151134) (-1.348866e-05, -0.00025178874) (-1.3779339e-05, -0.0002520522) (-1.4082595e-05, -0.00025230107) (-1.4397697e-05, -0.00025253477) (-1.4723887e-05, -0.00025275272) (-1.5060378e-05, -0.00025295441) (-1.540636e-05, -0.00025313934) (-1.5760999e-05, -0.00025330707) (-1.6123441e-05, -0.0002534572) (-1.6492814e-05, -0.00025358936) (-1.6868226e-05, -0.00025370324)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, closed, covered)
  pocket_cp_ch3 = polyline(z=0, xy: (0.0001475, -0.000375) (-0.0001475, -0.000375) (-0.00014867621, -0.00037494222) (-0.00014984108, -0.00037476942) (-0.00015098342, -0.00037448328) (-0.0001520922, -0.00037408655) (-0.00015315676, -0.00037358305) (-0.00015416684, -0.00037297763) (-0.00015511272, -0.00037227612) (-0.00015598528, -0.00037148528) (-0.00015677613, -0.00037061272) (-0.00015747764, -0.00036966684) (-0.00015808305, -0.00036865676) (-0.00015858655, -0.0003675922) (-0.00015898328, -0.00036648342) (-0.00015926942, -0.00036534108) (-0.00015944222, -0.00036417621) (-0.0001595, -0.000363) (-0.0001595, -0.00019) (-0.00015944222, -0.00018882379) (-0.00015926942, -0.00018765892) (-0.00015898328, -0.00018651658) (-0.00015858655, -0.0001854078) (-0.00015808305, -0.00018434324) (-0.00015747764, -0.00018333316) (-0.00015677613, -0.00018238728) (-0.00015598528, -0.00018151472) (-0.00015511272, -0.00018072388) (-0.00015416684, -0.00018002237) (-0.00015315676, -0.00017941694) (-0.0001520922, -0.00017891345) (-0.00015098342, -0.00017851672) (-0.00014984108, -0.00017823058) (-0.00014867621, -0.00017805778) (-0.0001475, -0.000178) (0.0001475, -0.000178) (0.00014867621, -0.00017805778) (0.00014984108, -0.00017823058) (0.00015098342, -0.00017851672) (0.0001520922, -0.00017891345) (0.00015315676, -0.00017941694) (0.00015416684, -0.00018002237) (0.00015511272, -0.00018072388) (0.00015598528, -0.00018151472) (0.00015677613, -0.00018238728) (0.00015747764, -0.00018333316) (0.00015808305, -0.00018434324) (0.00015858655, -0.0001854078) (0.00015898328, -0.00018651658) (0.00015926942, -0.00018765892) (0.00015944222, -0.00018882379) (0.0001595, -0.00019) (0.0001595, -0.000363) (0.00015944222, -0.00036417621) (0.00015926942, -0.00036534108) (0.00015898328, -0.00036648342) (0.00015858655, -0.0003675922) (0.00015808305, -0.00036865676) (0.00015747764, -0.00036966684) (0.00015677613, -0.00037061272) (0.00015598528, -0.00037148528) (0.00015511272, -0.00037227612) (0.00015416684, -0.00037297763) (0.00015315676, -0.00037358305) (0.0001520922, -0.00037408655) (0.00015098342, -0.00037448328) (0.00014984108, -0.00037476942) (0.00014867621, -0.00037494222) (0.0001475, -0.000375), closed, covered)
  tap_trace_jf_ch3 [copper] = polyline(z=0, xy: (5e-06, -0.001465) (5e-06, -0.00161) (2.5e-05, -0.00161) (2.5e-05, -0.00162) (5e-06, -0.00162) (5e-06, -0.001765) (-5e-06, -0.001765) (-5e-06, -0.001465) (5e-06, -0.001465), closed, covered)
  tap_cut_jf_ch3 = polyline(z=0, xy: (1.1e-05, -0.001465) (1.1e-05, -0.001604) (2.5e-05, -0.001604) (2.5e-05, -0.001626) (1.1e-05, -0.001626) (1.1e-05, -0.001765) (-1.1e-05, -0.001765) (-1.1e-05, -0.001465) (1.1e-05, -0.001465), closed, covered)
  tap_trace_jr_ch3 [copper] = polyline(z=0, xy: (0.000175, -0.00161) (0.000195, -0.00161) (0.000195, -0.001465) (0.000205, -0.001465) (0.000205, -0.001765) (0.000195, -0.001765) (0.000195, -0.00162) (0.000175, -0.00162) (0.000175, -0.00161), closed, covered)
  tap_cut_jr_ch3 = polyline(z=0, xy: (0.000175, -0.001604) (0.000189, -0.001604) (0.000189, -0.001465) (0.000211, -0.001465) (0.000211, -0.001765) (0.000189, -0.001765) (0.000189, -0.001626) (0.000175, -0.001626) (0.000175, -0.001604), closed, covered)
  head_a_cj_ch3 [copper] = polyline(z=0, xy: (5.7e-05, -0.0016475) (5.6803966e-05, -0.0016474904) (5.6609819e-05, -0.0016474616) (5.6419431e-05, -0.0016474139) (5.6234633e-05, -0.0016473478) (5.6057207e-05, -0.0016472638) (5.588886e-05, -0.0016471629) (5.5731213e-05, -0.001647046) (5.5585786e-05, -0.0016469142) (5.5453979e-05, -0.0016467688) (5.5337061e-05, -0.0016466111) (5.5236157e-05, -0.0016464428) (5.5152241e-05, -0.0016462654) (5.5086119e-05, -0.0016460806) (5.5038429e-05, -0.0016458902) (5.5009631e-05, -0.001645696) (5.5e-05, -0.0016455) (5.5e-05, -0.0015845) (5.5009631e-05, -0.001584304) (5.5038429e-05, -0.0015841098) (5.5086119e-05, -0.0015839194) (5.5152241e-05, -0.0015837346) (5.5236157e-05, -0.0015835572) (5.5337061e-05, -0.0015833889) (5.5453979e-05, -0.0015832312) (5.5585786e-05, -0.0015830858) (5.5731213e-05, -0.001582954) (5.588886e-05, -0.0015828371) (5.6057207e-05, -0.0015827362) (5.6234633e-05, -0.0015826522) (5.6419431e-05, -0.0015825861) (5.6609819e-05, -0.0015825384) (5.6803966e-05, -0.0015825096) (5.7e-05, -0.0015825) (7.8e-05, -0.0015825) (7.8196034e-05, -0.0015825096) (7.8390181e-05, -0.0015825384) (7.8580569e-05, -0.0015825861) (7.8765367e-05, -0.0015826522) (7.8942793e-05, -0.0015827362) (7.911114e-05, -0.0015828371) (7.9268787e-05, -0.001582954) (7.9414214e-05, -0.0015830858) (7.9546021e-05, -0.0015832312) (7.9662939e-05, -0.0015833889) (7.9763843e-05, -0.0015835572) (7.9847759e-05, -0.0015837346) (7.9913881e-05, -0.0015839194) (7.9961571e-05, -0.0015841098) (7.9990369e-05, -0.001584304) (8e-05, -0.0015845) (8e-05, -0.0016455) (7.9990369e-05, -0.001645696) (7.9961571e-05, -0.0016458902) (7.9913881e-05, -0.0016460806) (7.9847759e-05, -0.0016462654) (7.9763843e-05, -0.0016464428) (7.9662939e-05, -0.0016466111) (7.9546021e-05, -0.0016467688) (7.9414214e-05, -0.0016469142) (7.9268787e-05, -0.001647046) (7.911114e-05, -0.0016471629) (7.8942793e-05, -0.0016472638) (7.8765367e-05, -0.0016473478) (7.8580569e-05, -0.0016474139) (7.8390181e-05, -0.0016474616) (7.8196034e-05, -0.0016474904) (7.8e-05, -0.0016475) (5.7e-05, -0.0016475), closed, covered)
  head_b_cj_ch3 [copper] = polyline(z=0, xy: (0.000122, -0.0016475) (0.00012180397, -0.0016474904) (0.00012160982, -0.0016474616) (0.00012141943, -0.0016474139) (0.00012123463, -0.0016473478) (0.00012105721, -0.0016472638) (0.00012088886, -0.0016471629) (0.00012073121, -0.001647046) (0.00012058579, -0.0016469142) (0.00012045398, -0.0016467688) (0.00012033706, -0.0016466111) (0.00012023616, -0.0016464428) (0.00012015224, -0.0016462654) (0.00012008612, -0.0016460806) (0.00012003843, -0.0016458902) (0.00012000963, -0.001645696) (0.00012, -0.0016455) (0.00012, -0.0015845) (0.00012000963, -0.001584304) (0.00012003843, -0.0015841098) (0.00012008612, -0.0015839194) (0.00012015224, -0.0015837346) (0.00012023616, -0.0015835572) (0.00012033706, -0.0015833889) (0.00012045398, -0.0015832312) (0.00012058579, -0.0015830858) (0.00012073121, -0.001582954) (0.00012088886, -0.0015828371) (0.00012105721, -0.0015827362) (0.00012123463, -0.0015826522) (0.00012141943, -0.0015825861) (0.00012160982, -0.0015825384) (0.00012180397, -0.0015825096) (0.000122, -0.0015825) (0.000143, -0.0015825) (0.00014319603, -0.0015825096) (0.00014339018, -0.0015825384) (0.00014358057, -0.0015825861) (0.00014376537, -0.0015826522) (0.00014394279, -0.0015827362) (0.00014411114, -0.0015828371) (0.00014426879, -0.001582954) (0.00014441421, -0.0015830858) (0.00014454602, -0.0015832312) (0.00014466294, -0.0015833889) (0.00014476384, -0.0015835572) (0.00014484776, -0.0015837346) (0.00014491388, -0.0015839194) (0.00014496157, -0.0015841098) (0.00014499037, -0.001584304) (0.000145, -0.0015845) (0.000145, -0.0016455) (0.00014499037, -0.001645696) (0.00014496157, -0.0016458902) (0.00014491388, -0.0016460806) (0.00014484776, -0.0016462654) (0.00014476384, -0.0016464428) (0.00014466294, -0.0016466111) (0.00014454602, -0.0016467688) (0.00014441421, -0.0016469142) (0.00014426879, -0.001647046) (0.00014411114, -0.0016471629) (0.00014394279, -0.0016472638) (0.00014376537, -0.0016473478) (0.00014358057, -0.0016474139) (0.00014339018, -0.0016474616) (0.00014319603, -0.0016474904) (0.000143, -0.0016475) (0.000122, -0.0016475), closed, covered)
  pocket_cj_ch3 = polyline(z=0, xy: (4.1e-05, -0.0016635) (4.0803966e-05, -0.0016634904) (4.0609819e-05, -0.0016634616) (4.0419431e-05, -0.0016634139) (4.0234633e-05, -0.0016633478) (4.0057207e-05, -0.0016632638) (3.988886e-05, -0.0016631629) (3.9731213e-05, -0.001663046) (3.9585786e-05, -0.0016629142) (3.9453979e-05, -0.0016627688) (3.9337061e-05, -0.0016626111) (3.9236157e-05, -0.0016624428) (3.9152241e-05, -0.0016622654) (3.9086119e-05, -0.0016620806) (3.9038429e-05, -0.0016618902) (3.9009631e-05, -0.001661696) (3.9e-05, -0.0016615) (3.9e-05, -0.0015685) (3.9009631e-05, -0.001568304) (3.9038429e-05, -0.0015681098) (3.9086119e-05, -0.0015679194) (3.9152241e-05, -0.0015677346) (3.9236157e-05, -0.0015675572) (3.9337061e-05, -0.0015673889) (3.9453979e-05, -0.0015672312) (3.9585786e-05, -0.0015670858) (3.9731213e-05, -0.001566954) (3.988886e-05, -0.0015668371) (4.0057207e-05, -0.0015667362) (4.0234633e-05, -0.0015666522) (4.0419431e-05, -0.0015665861) (4.0609819e-05, -0.0015665384) (4.0803966e-05, -0.0015665096) (4.1e-05, -0.0015665) (0.000159, -0.0015665) (0.00015919603, -0.0015665096) (0.00015939018, -0.0015665384) (0.00015958057, -0.0015665861) (0.00015976537, -0.0015666522) (0.00015994279, -0.0015667362) (0.00016011114, -0.0015668371) (0.00016026879, -0.001566954) (0.00016041421, -0.0015670858) (0.00016054602, -0.0015672312) (0.00016066294, -0.0015673889) (0.00016076384, -0.0015675572) (0.00016084776, -0.0015677346) (0.00016091388, -0.0015679194) (0.00016096157, -0.0015681098) (0.00016099037, -0.001568304) (0.000161, -0.0015685) (0.000161, -0.0016615) (0.00016099037, -0.001661696) (0.00016096157, -0.0016618902) (0.00016091388, -0.0016620806) (0.00016084776, -0.0016622654) (0.00016076384, -0.0016624428) (0.00016066294, -0.0016626111) (0.00016054602, -0.0016627688) (0.00016041421, -0.0016629142) (0.00016026879, -0.001663046) (0.00016011114, -0.0016631629) (0.00015994279, -0.0016632638) (0.00015976537, -0.0016633478) (0.00015958057, -0.0016634139) (0.00015939018, -0.0016634616) (0.00015919603, -0.0016634904) (0.000159, -0.0016635) (4.1e-05, -0.0016635), closed, covered)
  endcap_filt_ch3_start = rectangle(corner=(-0.000311, -0.000915, 0), x_size=2.2e-05, y_size=6e-06)
  endcap_res_ch3_start = rectangle(corner=(0.000539, -0.00255834, 0), x_size=2.2e-05, y_size=6e-06)
  endcap_res_a_ch3_start = rectangle(corner=(0.000189, -0.002921, 0), x_size=2.2e-05, y_size=6e-06)
  ground_main_plane [copper] = rectangle(corner=(-0.0017985, -0.003115, 0), x_size=0.003597, y_size=0.0034915)
  main [silicon] = box(corner=(-0.0017985, -0.003115, -0.000525), size=(0.003597, 0.0034915, 0.000525))
  ground_main_plane.subtract(pocket_cp_ch3, endcap_filt_ch3_start, endcap_res_a_ch3_start, lead_b_sub_cp_ch3, cut_feed_jf_ch3, cut_feed_out, cut_res_ch3, tap_cut_n0_ch3, tap_cut_jr_ch3, pocket_cj_ch3, cut_res_a_ch3, cut_stub_r_ch3, cut_stub_f_ch3, lead_a_sub_cp_ch3, cut_filt_ch3, endcap_res_ch3_start, cut_stub_p_ch3, lead_a_sub_cj_ch3, cut_feed_in, pocket_LPPin, lead_b_sub_cj_ch3, pocket_LPPout, tap_cut_jf_ch3)
boundaries and excitations:
  ThinCond1: ThinConductor Objects=[lead_a_cp_ch3, lead_b_cp_ch3, trace_stub_p_ch3, trace_feed_jf_ch3, lead_a_cj_ch3, lead_b_cj_ch3, trace_stub_f_ch3, trace_stub_r_ch3, trace_res_a_ch3, trace_filt_ch3, trace_res_ch3, trace_feed_in, trace_feed_out, launch_pad_LPPin, launch_pad_LPPout, tap_trace_n0_ch3, plate_cp_ch3, frame_cp_ch3, tap_trace_jf_ch3, tap_trace_jr_ch3, head_a_cj_ch3, head_b_cj_ch3, ground_main_plane] Material=pec Thickness=200nm
  frame_cp_ch3: SignalNet Objects=[lead_a_cp_ch3, trace_feed_jf_ch3, lead_a_cj_ch3, trace_stub_f_ch3, trace_filt_ch3, frame_cp_ch3, tap_trace_jf_ch3, head_a_cj_ch3]
  launch_pad_LPPin: SignalNet Objects=[lead_b_cp_ch3, trace_stub_p_ch3, trace_feed_in, trace_feed_out, launch_pad_LPPin, launch_pad_LPPout, tap_trace_n0_ch3, plate_cp_ch3]
  head_b_cj_ch3: SignalNet Objects=[lead_b_cj_ch3, trace_stub_r_ch3, trace_res_a_ch3, trace_res_ch3, tap_trace_jr_ch3, head_b_cj_ch3]
  g_wb: SignalNet Objects=[g_wb, g_wb_1..g_wb_17, ground_main_plane]
setups:
  Setup: Matrix AdaptiveFreq=6.7GHz Cap{MaxPass=15 MinPass=2 MinConvPass=2 PerError=0.3 PerRefine=30 AutoIncreaseSolutionOrder SolutionOrder=Normal Solver_Type=Iterative}
source amplitudes:
  frame_cp_ch3: Cap 1V 0deg
  g_wb, head_b_cj_ch3, launch_pad_LPPin: Cap 0V 0deg

design q3d6_full_2105_q3d (Q3D Extractor, model units mm)
options: SParamCalcMethod=EqTransLine Calculate_Lossy_Dielectrics
geometry:
  lead_a_cp_ch3_path = polyline((0, -0.000362999, 0) (0, -0.000415, 0))
  lead_a_cp_ch3 [copper] = polyline((5e-06, -0.000362999, 0) (-5e-06, -0.000362999, 0))
  lead_a_cp_ch3.sweep_along_path(lead_a_cp_ch3_path)
  lead_a_sub_cp_ch3_path = polyline((0, -0.000362999, 0) (0, -0.000415, 0))
  lead_a_sub_cp_ch3 = polyline((1.1e-05, -0.000362999, 0) (-1.1e-05, -0.000362999, 0))
  lead_a_sub_cp_ch3.sweep_along_path(lead_a_sub_cp_ch3_path)
  lead_b_cp_ch3_path = polyline((0, -0.000262001, 0) (0, -0.00015, 0))
  lead_b_cp_ch3 [copper] = polyline((-5e-06, -0.000262001, 0) (5e-06, -0.000262001, 0))
  lead_b_cp_ch3.sweep_along_path(lead_b_cp_ch3_path)
  lead_b_sub_cp_ch3_path = polyline((0, -0.000262001, 0) (0, -0.00015, 0))
  lead_b_sub_cp_ch3 = polyline((-1.1e-05, -0.000262001, 0) (1.1e-05, -0.000262001, 0))
  lead_b_sub_cp_ch3.sweep_along_path(lead_b_sub_cp_ch3_path)
  trace_stub_p_ch3_path = polyline((0, -0.0001, 0) (0, -0.00015, 0))
  trace_stub_p_ch3 [copper] = polyline((5e-06, -0.0001, 0) (-5e-06, -0.0001, 0))
  trace_stub_p_ch3.sweep_along_path(trace_stub_p_ch3_path)
  cut_stub_p_ch3_path = polyline((0, -0.0001, 0) (0, -0.00015, 0))
  cut_stub_p_ch3 = polyline((1.1e-05, -0.0001, 0) (-1.1e-05, -0.0001, 0))
  cut_stub_p_ch3.sweep_along_path(cut_stub_p_ch3_path)
  trace_feed_jf_ch3_path = polyline((0, -0.000415, 0) (0, -0.001465, 0))
  trace_feed_jf_ch3 [copper] = polyline((5e-06, -0.000415, 0) (-5e-06, -0.000415, 0))
  trace_feed_jf_ch3.sweep_along_path(trace_feed_jf_ch3_path)
  cut_feed_jf_ch3_path = polyline((0, -0.000415, 0) (0, -0.001465, 0))
  cut_feed_jf_ch3 = polyline((1.1e-05, -0.000415, 0) (-1.1e-05, -0.000415, 0))
  cut_feed_jf_ch3.sweep_along_path(cut_feed_jf_ch3_path)
  lead_a_cj_ch3_path = polyline((4.5001e-05, -0.001615, 0) (3.5e-05, -0.001615, 0))
  lead_a_cj_ch3 [copper] = polyline((4.5001e-05, -0.00162, 0) (4.5001e-05, -0.00161, 0))
  lead_a_cj_ch3.sweep_along_path(lead_a_cj_ch3_path)
  lead_a_sub_cj_ch3_path = polyline((4.5001e-05, -0.001615, 0) (3.5e-05, -0.001615, 0))
  lead_a_sub_cj_ch3 = polyline((4.5001e-05, -0.001626, 0) (4.5001e-05, -0.001604, 0))
  lead_a_sub_cj_ch3.sweep_along_path(lead_a_sub_cj_ch3_path)
  lead_b_cj_ch3_path = polyline((0.000154999, -0.001615, 0) (0.000165, -0.001615, 0))
  lead_b_cj_ch3 [copper] = polyline((0.000154999, -0.00161, 0) (0.000154999, -0.00162, 0))
  lead_b_cj_ch3.sweep_along_path(lead_b_cj_ch3_path)
  lead_b_sub_cj_ch3_path = polyline((0.000154999, -0.001615, 0) (0.000165, -0.001615, 0))
  lead_b_sub_cj_ch3 = polyline((0.000154999, -0.001604, 0) (0.000154999, -0.001626, 0))
  lead_b_sub_cj_ch3.sweep_along_path(lead_b_sub_cj_ch3_path)
  trace_stub_f_ch3_path = polyline((1.5e-05, -0.001615, 0) (3.5e-05, -0.001615, 0))
  trace_stub_f_ch3 [copper] = polyline((1.5e-05, -0.00161, 0) (1.5e-05, -0.00162, 0))
  trace_stub_f_ch3.sweep_along_path(trace_stub_f_ch3_path)
  cut_stub_f_ch3_path = polyline((1.5e-05, -0.001615, 0) (3.5e-05, -0.001615, 0))
  cut_stub_f_ch3 = polyline((1.5e-05, -0.001604, 0) (1.5e-05, -0.001626, 0))
  cut_stub_f_ch3.sweep_along_path(cut_stub_f_ch3_path)
  trace_stub_r_ch3_path = polyline((0.000185, -0.001615, 0) (0.000165, -0.001615, 0))
  trace_stub_r_ch3 [copper] = polyline((0.000185, -0.00162, 0) (0.000185, -0.00161, 0))
  trace_stub_r_ch3.sweep_along_path(trace_stub_r_ch3_path)
  cut_stub_r_ch3_path = polyline((0.000185, -0.001615, 0) (0.000165, -0.001615, 0))
  cut_stub_r_ch3 = polyline((0.000185, -0.001626, 0) (0.000185, -0.001604, 0))
  cut_stub_r_ch3.sweep_along_path(cut_stub_r_ch3_path)
  trace_res_a_ch3_path = polyline((0.0002, -0.002915, 0) (0.0002, -0.001765, 0))
  trace_res_a_ch3 [copper] = polyline((0.000195, -0.002915, 0) (0.000205, -0.002915, 0))
  trace_res_a_ch3.sweep_along_path(trace_res_a_ch3_path)
  cut_res_a_ch3_path = polyline((0.0002, -0.002915, 0) (0.0002, -0.001765, 0))
  cut_res_a_ch3 = polyline((0.000189, -0.002915, 0) (0.000211, -0.002915, 0))
  cut_res_a_ch3.sweep_along_path(cut_res_a_ch3_path)
  trace_filt_ch3_path = polyline(z=0, xy: (-0.0003, -0.000915) (-0.0003, -0.0022822498) (0, -0.0022822498) (0, -0.001765))
  trace_filt_ch3_path.fillet(Vertices=trace_filt_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  trace_filt_ch3 [copper] = polyline((-0.000295, -0.000915, 0) (-0.000305, -0.000915, 0))
  trace_filt_ch3.sweep_along_path(trace_filt_ch3_path)
  cut_filt_ch3_path = polyline(z=0, xy: (-0.0003, -0.000915) (-0.0003, -0.0022822498) (0, -0.0022822498) (0, -0.001765))
  cut_filt_ch3_path.fillet(Vertices=cut_filt_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  cut_filt_ch3 = polyline((-0.000289, -0.000915, 0) (-0.000311, -0.000915, 0))
  cut_filt_ch3.sweep_along_path(cut_filt_ch3_path)
  trace_res_ch3_path = polyline(z=0, xy: (0.00055, -0.00255234) (0.00055, -0.000665) (0.0002, -0.000665) (0.0002, -0.001465))
  trace_res_ch3_path.fillet(Vertices=trace_res_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  trace_res_ch3 [copper] = polyline((0.000545, -0.00255234, 0) (0.000555, -0.00255234, 0))
  trace_res_ch3.sweep_along_path(trace_res_ch3_path)
  cut_res_ch3_path = polyline(z=0, xy: (0.00055, -0.00255234) (0.00055, -0.000665) (0.0002, -0.000665) (0.0002, -0.001465))
  cut_res_ch3_path.fillet(Vertices=cut_res_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  cut_res_ch3 = polyline((0.000539, -0.00255234, 0) (0.000561, -0.00255234, 0))
  cut_res_ch3.sweep_along_path(cut_res_ch3_path)
  trace_feed_in_path = polyline((-0.00117, 0, 0) (-0.00015, 0, 0))
  trace_feed_in [copper] = polyline((-0.00117, 5e-06, 0) (-0.00117, -5e-06, 0))
  trace_feed_in.sweep_along_path(trace_feed_in_path)
  cut_feed_in_path = polyline((-0.00117, 0, 0) (-0.00015, 0, 0))
  cut_feed_in = polyline((-0.00117, 1.1e-05, 0) (-0.00117, -1.1e-05, 0))
  cut_feed_in.sweep_along_path(cut_feed_in_path)
  trace_feed_out_path = polyline((0.00015, 0, 0) (0.00117, 0, 0))
  trace_feed_out [copper] = polyline((0.00015, 5e-06, 0) (0.00015, -5e-06, 0))
  trace_feed_out.sweep_along_path(trace_feed_out_path)
  cut_feed_out_path = polyline((0.00015, 0, 0) (0.00117, 0, 0))
  cut_feed_out = polyline((0.00015, 1.1e-05, 0) (0.00015, -1.1e-05, 0))
  cut_feed_out.sweep_along_path(cut_feed_out_path)
  g_wb [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-5.5e-05 YPadPos=-0.000765 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_1 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-5.5e-05 YPadPos=-0.001115 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_2 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000255 YPadPos=-0.0025316667 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_3 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000255 YPadPos=-0.0021483333 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_4 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0012568124 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_5 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0015986249 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_6 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0019404373 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_7 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=5.5e-05 YPadPos=-0.0020236249 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_8 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.002174872 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_9 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001797404 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_10 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001419936 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_11 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001042468 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_12 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000145 YPadPos=-0.00093166667 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_13 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000145 YPadPos=-0.0011983333 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_14 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00083 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_15 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00049 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_16 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00049 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_17 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00083 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  launch_pad_LPPin [copper] = polyline(z=0, xy: (-0.0012, 5e-06) (-0.001322, 0.0001) (-0.001522, 0.0001) (-0.001522, -0.0001) (-0.001322, -0.0001) (-0.0012, -5e-06) (-0.00117, -5e-06) (-0.00117, 5e-06) (-0.0012, 5e-06), closed, covered)
  pocket_LPPin = polyline(z=0, xy: (-0.0012, 1.1e-05) (-0.001322, 0.0001765) (-0.0015985, 0.0001765) (-0.0015985, -0.0001765) (-0.001322, -0.0001765) (-0.0012, -1.1e-05) (-0.00117, -1.1e-05) (-0.00117, 1.1e-05) (-0.0012, 1.1e-05), closed, covered)
  launch_pad_LPPout [copper] = polyline(z=0, xy: (0.0012, -5e-06) (0.001322, -0.0001) (0.001522, -0.0001) (0.001522, 0.0001) (0.001322, 0.0001) (0.0012, 5e-06) (0.00117, 5e-06) (0.00117, -5e-06) (0.0012, -5e-06), closed, covered)
  pocket_LPPout = polyline(z=0, xy: (0.0012, -1.1e-05) (0.001322, -0.0001765) (0.0015985, -0.0001765) (0.0015985, 0.0001765) (0.001322, 0.0001765) (0.0012, 1.1e-05) (0.00117, 1.1e-05) (0.00117, -1.1e-05) (0.0012, -1.1e-05), closed, covered)
  tap_trace_n0_ch3 [copper] = polyline(z=0, xy: (-5e-06, -0.0001) (-5e-06, -5e-06) (-0.00015, -5e-06) (-0.00015, 5e-06) (0.00015, 5e-06) (0.00015, -5e-06) (5e-06, -5e-06) (5e-06, -0.0001) (-5e-06, -0.0001), closed, covered)
  tap_cut_n0_ch3 = polyline(z=0, xy: (-1.1e-05, -0.0001) (-1.1e-05, -1.1e-05) (-0.00015, -1.1e-05) (-0.00015, 1.1e-05) (0.00015, 1.1e-05) (0.00015, -1.1e-05) (1.1e-05, -1.1e-05) (1.1e-05, -0.0001) (-1.1e-05, -0.0001), closed, covered)
  plate_cp_ch3 [copper] = polyline(z=0, xy: (8.25e-05, -0.000295) (8.2461478e-05, -0.00029578414) (8.2346282e-05, -0.00029656072) (8.2155523e-05, -0.00029732228) (8.1891036e-05, -0.00029806147) (8.155537e-05, -0.00029877117) (8.1151757e-05, -0.00029944456) (8.0684084e-05, -0.00030007515) (8.0156854e-05, -0.00030065685) (7.9575146e-05, -0.00030118408) (7.8944562e-05, -0.00030165176) (7.8271174e-05, -0.00030205537) (7.7561467e-05, -0.00030239104) (7.6822277e-05, -0.00030265552) (7.6060723e-05, -0.00030284628) (7.5284137e-05, -0.00030296148) (7.45e-05, -0.000303) (-7.45e-05, -0.000303) (-7.5284137e-05, -0.00030296148) (-7.6060723e-05, -0.00030284628) (-7.6822277e-05, -0.00030265552) (-7.7561467e-05, -0.00030239104) (-7.8271174e-05, -0.00030205537) (-7.8944562e-05, -0.00030165176) (-7.9575146e-05, -0.00030118408) (-8.0156854e-05, -0.00030065685) (-8.0684084e-05, -0.00030007515) (-8.1151757e-05, -0.00029944456) (-8.155537e-05, -0.00029877117) (-8.1891036e-05, -0.00029806147) (-8.2155523e-05, -0.00029732228) (-8.2346282e-05, -0.00029656072) (-8.2461478e-05, -0.00029578414) (-8.25e-05, -0.000295) (-8.25e-05, -0.00027) (-8.2461478e-05, -0.00026921586) (-8.2346282e-05, -0.00026843928) (-8.2155523e-05, -0.00026767772) (-8.1891036e-05, -0.00026693853) (-8.155537e-05, -0.00026622883) (-8.1151757e-05, -0.00026555544) (-8.0684084e-05, -0.00026492485) (-8.0156854e-05, -0.00026434315) (-7.9575146e-05, -0.00026381592) (-7.8944562e-05, -0.00026334824) (-7.8271174e-05, -0.00026294463) (-7.7561467e-05, -0.00026260896) (-7.6822277e-05, -0.00026234448) (-7.6060723e-05, -0.00026215372) (-7.5284137e-05, -0.00026203852) (-7.45e-05, -0.000262) (7.45e-05, -0.000262) (7.5284137e-05, -0.00026203852) (7.6060723e-05, -0.00026215372) (7.6822277e-05, -0.00026234448) (7.7561467e-05, -0.00026260896) (7.8271174e-05, -0.00026294463) (7.8944562e-05, -0.00026334824) (7.9575146e-05, -0.00026381592) (8.0156854e-05, -0.00026434315) (8.0684084e-05, -0.00026492485) (8.1151757e-05, -0.00026555544) (8.155537e-05, -0.00026622883) (8.1891036e-05, -0.00026693853) (8.2155523e-05, -0.00026767772) (8.2346282e-05, -0.00026843928) (8.2461478e-05, -0.00026921586) (8.25e-05, -0.00027) (8.25e-05, -0.000295), closed, covered)
  frame_cp_ch3 [copper] = polyline(z=0, xy: (8.25e-05, -0.000311) (8.3284137e-05, -0.00031096148) (8.4060723e-05, -0.00031084628) (8.4822277e-05, -0.00031065552) (8.5561467e-05, -0.00031039104) (8.6271174e-05, -0.00031005537) (8.6944562e-05, -0.00030965176) (8.7575146e-05, -0.00030918408) (8.8156854e-05, -0.00030865685) (8.8684084e-05, -0.00030807515) (8.9151757e-05, -0.00030744456) (8.955537e-05, -0.00030677117) (8.9891036e-05, -0.00030606147) (9.0155523e-05, -0.00030532228) (9.0346282e-05, -0.00030456072) (9.0461478e-05, -0.00030378414) (9.05e-05, -0.000303) (9.05e-05, -0.000262) (9.0461478e-05, -0.00026121586) (9.0346282e-05, -0.00026043928) (9.0155523e-05, -0.00025967772) (8.9891036e-05, -0.00025893853) (8.955537e-05, -0.00025822883) (8.9151757e-05, -0.00025755544) (8.8684084e-05, -0.00025692485) (8.8156854e-05, -0.00025634315) (8.7575146e-05, -0.00025581592) (8.6944562e-05, -0.00025534824) (8.6271174e-05, -0.00025494463) (8.5561467e-05, -0.00025460896) (8.4822277e-05, -0.00025434448) (8.4060723e-05, -0.00025415372) (8.3284137e-05, -0.00025403852) (8.25e-05, -0.000254) (1.909818e-05, -0.000254) (1.8901939e-05, -0.00025399518) (1.8412015e-05, -0.00025397111) (1.80216e-05, -0.00025393266) (1.7633541e-05, -0.0002538751) (1.7248774e-05, -0.00025379856) (1.6868226e-05, -0.00025370324) (1.6492814e-05, -0.00025358936) (1.6123441e-05, -0.0002534572) (1.5760999e-05, -0.00025330707) (1.540636e-05, -0.00025313934) (1.5060378e-05, -0.00025295441) (1.4723887e-05, -0.00025275272) (1.4397697e-05, -0.00025253477) (1.4082595e-05, -0.00025230107) (1.3779339e-05, -0.0002520522) (1.348866e-05, -0.00025178874) (1.3211259e-05, -0.00025151134) (1.2947803e-05, -0.00025122066) (1.2698928e-05, -0.0002509174) (1.2465232e-05, -0.0002506023) (1.2247279e-05, -0.00025027611) (1.2045594e-05, -0.00024993962) (1.1860663e-05, -0.00024959364) (1.1692931e-05, -0.000249239) (1.1542802e-05, -0.00024887656) (1.1410639e-05, -0.00024850719) (1.1296759e-05, -0.00024813177) (1.1201436e-05, -0.00024775123) (1.1124902e-05, -0.00024736646) (1.1067338e-05, -0.0002469784) (1.1028886e-05, -0.00024658799) (1.1004817e-05, -0.00024609806) (1.1e-05, -0.00024590182) (1.1e-05, -0.00019809818) (1.1004817e-05, -0.00019790194) (1.1028886e-05, -0.00019741201) (1.1067338e-05, -0.0001970216) (1.1124902e-05, -0.00019663354) (1.1201436e-05, -0.00019624877) (1.1296759e-05, -0.00019586823) (1.1410639e-05, -0.00019549281) (1.1542802e-05, -0.00019512344) (1.1692931e-05, -0.000194761) (1.1860663e-05, -0.00019440636) (1.2045594e-05, -0.00019406038) (1.2247279e-05, -0.00019372389) (1.2465232e-05, -0.0001933977) (1.2698928e-05, -0.00019308259) (1.2947803e-05, -0.00019277934) (1.3211259e-05, -0.00019248866) (1.348866e-05, -0.00019221126) (1.3779339e-05, -0.0001919478) (1.4082595e-05, -0.00019169893) (1.4397697e-05, -0.00019146523) (1.4723887e-05, -0.00019124728) (1.5060378e-05, -0.00019104559) (1.540636e-05, -0.00019086066) (1.5760999e-05, -0.00019069293) (1.6123441e-05, -0.0001905428) (1.6492814e-05, -0.00019041064) (1.6868226e-05, -0.00019029676) (1.7248774e-05, -0.00019020144) (1.7633541e-05, -0.0001901249) (1.80216e-05, -0.00019006734) (1.8412015e-05, -0.00019002889) (1.8901939e-05, -0.00019000482) (1.909818e-05, -0.00019) (0.00013940182, -0.00019) (0.00013959806, -0.00019000482) (0.00014008798, -0.00019002889) (0.0001404784, -0.00019006734) (0.00014086646, -0.0001901249) (0.00014125123, -0.00019020144) (0.00014163177, -0.00019029676) (0.00014200719, -0.00019041064) (0.00014237656, -0.0001905428) (0.000142739, -0.00019069293) (0.00014309364, -0.00019086066) (0.00014343962, -0.00019104559) (0.00014377611, -0.00019124728) (0.0001441023, -0.00019146523) (0.0001444174, -0.00019169893) (0.00014472066, -0.0001919478) (0.00014501134, -0.00019221126) (0.00014528874, -0.00019248866) (0.0001455522, -0.00019277934) (0.00014580107, -0.00019308259) (0.00014603477, -0.0001933977) (0.00014625272, -0.00019372389) (0.00014645441, -0.00019406038) (0.00014663934, -0.00019440636) (0.00014680707, -0.000194761) (0.0001469572, -0.00019512344) (0.00014708936, -0.00019549281) (0.00014720324, -0.00019586823) (0.00014729856, -0.00019624877) (0.0001473751, -0.00019663354) (0.00014743266, -0.0001970216) (0.00014747111, -0.00019741201) (0.00014749518, -0.00019790194) (0.0001475, -0.00019809818) (0.0001475, -0.00035490182) (0.00014749518, -0.00035509806) (0.00014747111, -0.00035558799) (0.00014743266, -0.0003559784) (0.0001473751, -0.00035636646) (0.00014729856, -0.00035675123) (0.00014720324, -0.00035713177) (0.00014708936, -0.00035750719) (0.0001469572, -0.00035787656) (0.00014680707, -0.000358239) (0.00014663934, -0.00035859364) (0.00014645441, -0.00035893962) (0.00014625272, -0.00035927611) (0.00014603477, -0.0003596023) (0.00014580107, -0.00035991741) (0.0001455522, -0.00036022066) (0.00014528874, -0.00036051134) (0.00014501134, -0.00036078874) (0.00014472066, -0.0003610522) (0.0001444174, -0.00036130107) (0.0001441023, -0.00036153477) (0.00014377611, -0.00036175272) (0.00014343962, -0.00036195441) (0.00014309364, -0.00036213934) (0.000142739, -0.00036230707) (0.00014237656, -0.0003624572) (0.00014200719, -0.00036258936) (0.00014163177, -0.00036270324) (0.00014125123, -0.00036279856) (0.00014086646, -0.0003628751) (0.0001404784, -0.00036293266) (0.00014008798, -0.00036297111) (0.00013959806, -0.00036299518) (0.00013940182, -0.000363) (-0.00013940182, -0.000363) (-0.00013959806, -0.00036299518) (-0.00014008798, -0.00036297111) (-0.0001404784, -0.00036293266) (-0.00014086646, -0.0003628751) (-0.00014125123, -0.00036279856) (-0.00014163177, -0.00036270324) (-0.00014200719, -0.00036258936) (-0.00014237656, -0.0003624572) (-0.000142739, -0.00036230707) (-0.00014309364, -0.00036213934) (-0.00014343962, -0.00036195441) (-0.00014377611, -0.00036175272) (-0.0001441023, -0.00036153477) (-0.0001444174, -0.00036130107) (-0.00014472066, -0.0003610522) (-0.00014501134, -0.00036078874) (-0.00014528874, -0.00036051134) (-0.0001455522, -0.00036022066) (-0.00014580107, -0.00035991741) (-0.00014603477, -0.0003596023) (-0.00014625272, -0.00035927611) (-0.00014645441, -0.00035893962) (-0.00014663934, -0.00035859364) (-0.00014680707, -0.000358239) (-0.0001469572, -0.00035787656) (-0.00014708936, -0.00035750719) (-0.00014720324, -0.00035713177) (-0.00014729856, -0.00035675123) (-0.0001473751, -0.00035636646) (-0.00014743266, -0.0003559784) (-0.00014747111, -0.00035558799) (-0.00014749518, -0.00035509806) (-0.0001475, -0.00035490182) (-0.0001475, -0.00019809818) (-0.00014749518, -0.00019790194) (-0.00014747111, -0.00019741201) (-0.00014743266, -0.0001970216) (-0.0001473751, -0.00019663354) (-0.00014729856, -0.00019624877) (-0.00014720324, -0.00019586823) (-0.00014708936, -0.00019549281) (-0.0001469572, -0.00019512344) (-0.00014680707, -0.000194761) (-0.00014663934, -0.00019440636) (-0.00014645441, -0.00019406038) (-0.00014625272, -0.00019372389) (-0.00014603477, -0.0001933977) (-0.00014580107, -0.00019308259) (-0.0001455522, -0.00019277934) (-0.00014528874, -0.00019248866) (-0.00014501134, -0.00019221126) (-0.00014472066, -0.0001919478) (-0.0001444174, -0.00019169893) (-0.0001441023, -0.00019146523) (-0.00014377611, -0.00019124728) (-0.00014343962, -0.00019104559) (-0.00014309364, -0.00019086066) (-0.000142739, -0.00019069293) (-0.00014237656, -0.0001905428) (-0.00014200719, -0.00019041064) (-0.00014163177, -0.00019029676) (-0.00014125123, -0.00019020144) (-0.00014086646, -0.0001901249) (-0.0001404784, -0.00019006734) (-0.00014008798, -0.00019002889) (-0.00013959806, -0.00019000482) (-0.00013940182, -0.00019) (-1.909818e-05, -0.00019) (-1.8901939e-05, -0.00019000482) (-1.8412015e-05, -0.00019002889) (-1.80216e-05, -0.00019006734) (-1.7633541e-05, -0.0001901249) (-1.7248774e-05, -0.00019020144) (-1.6868226e-05, -0.00019029676) (-1.6492814e-05, -0.00019041064) (-1.6123441e-05, -0.0001905428) (-1.5760999e-05, -0.00019069293) (-1.540636e-05, -0.00019086066) (-1.5060378e-05, -0.00019104559) (-1.4723887e-05, -0.00019124728) (-1.4397697e-05, -0.00019146523) (-1.4082595e-05, -0.00019169893) (-1.3779339e-05, -0.0001919478) (-1.348866e-05, -0.00019221126) (-1.3211259e-05, -0.00019248866) (-1.2947803e-05, -0.00019277934) (-1.2698928e-05, -0.00019308259) (-1.2465232e-05, -0.0001933977) (-1.2247279e-05, -0.00019372389) (-1.2045594e-05, -0.00019406038) (-1.1860663e-05, -0.00019440636) (-1.1692931e-05, -0.000194761) (-1.1542802e-05, -0.00019512344) (-1.1410639e-05, -0.00019549281) (-1.1296759e-05, -0.00019586823) (-1.1201436e-05, -0.00019624877) (-1.1124902e-05, -0.00019663354) (-1.1067338e-05, -0.0001970216) (-1.1028886e-05, -0.00019741201) (-1.1004817e-05, -0.00019790194) (-1.1e-05, -0.00019809818) (-1.1e-05, -0.00024590182) (-1.1004817e-05, -0.00024609806) (-1.1028886e-05, -0.00024658799) (-1.1067338e-05, -0.0002469784) (-1.1124902e-05, -0.00024736646) (-1.1201436e-05, -0.00024775123) (-1.1296759e-05, -0.00024813177) (-1.1410639e-05, -0.00024850719) (-1.1542802e-05, -0.00024887656) (-1.1692931e-05, -0.000249239) (-1.1860663e-05, -0.00024959364) (-1.2045594e-05, -0.00024993962) (-1.2247279e-05, -0.00025027611) (-1.2465232e-05, -0.0002506023) (-1.2698928e-05, -0.0002509174) (-1.2947803e-05, -0.00025122066) (-1.3211259e-05, -0.00025151134) (-1.348866e-05, -0.00025178874) (-1.3779339e-05, -0.0002520522) (-1.4082595e-05, -0.00025230107) (-1.4397697e-05, -0.00025253477) (-1.4723887e-05, -0.00025275272) (-1.5060378e-05, -0.00025295441) (-1.540636e-05, -0.00025313934) (-1.5760999e-05, -0.00025330707) (-1.6123441e-05, -0.0002534572) (-1.6492814e-05, -0.00025358936) (-1.6868226e-05, -0.00025370324)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, closed, covered)
  pocket_cp_ch3 = polyline(z=0, xy: (0.0001475, -0.000375) (-0.0001475, -0.000375) (-0.00014867621, -0.00037494222) (-0.00014984108, -0.00037476942) (-0.00015098342, -0.00037448328) (-0.0001520922, -0.00037408655) (-0.00015315676, -0.00037358305) (-0.00015416684, -0.00037297763) (-0.00015511272, -0.00037227612) (-0.00015598528, -0.00037148528) (-0.00015677613, -0.00037061272) (-0.00015747764, -0.00036966684) (-0.00015808305, -0.00036865676) (-0.00015858655, -0.0003675922) (-0.00015898328, -0.00036648342) (-0.00015926942, -0.00036534108) (-0.00015944222, -0.00036417621) (-0.0001595, -0.000363) (-0.0001595, -0.00019) (-0.00015944222, -0.00018882379) (-0.00015926942, -0.00018765892) (-0.00015898328, -0.00018651658) (-0.00015858655, -0.0001854078) (-0.00015808305, -0.00018434324) (-0.00015747764, -0.00018333316) (-0.00015677613, -0.00018238728) (-0.00015598528, -0.00018151472) (-0.00015511272, -0.00018072388) (-0.00015416684, -0.00018002237) (-0.00015315676, -0.00017941694) (-0.0001520922, -0.00017891345) (-0.00015098342, -0.00017851672) (-0.00014984108, -0.00017823058) (-0.00014867621, -0.00017805778) (-0.0001475, -0.000178) (0.0001475, -0.000178) (0.00014867621, -0.00017805778) (0.00014984108, -0.00017823058) (0.00015098342, -0.00017851672) (0.0001520922, -0.00017891345) (0.00015315676, -0.00017941694) (0.00015416684, -0.00018002237) (0.00015511272, -0.00018072388) (0.00015598528, -0.00018151472) (0.00015677613, -0.00018238728) (0.00015747764, -0.00018333316) (0.00015808305, -0.00018434324) (0.00015858655, -0.0001854078) (0.00015898328, -0.00018651658) (0.00015926942, -0.00018765892) (0.00015944222, -0.00018882379) (0.0001595, -0.00019) (0.0001595, -0.000363) (0.00015944222, -0.00036417621) (0.00015926942, -0.00036534108) (0.00015898328, -0.00036648342) (0.00015858655, -0.0003675922) (0.00015808305, -0.00036865676) (0.00015747764, -0.00036966684) (0.00015677613, -0.00037061272) (0.00015598528, -0.00037148528) (0.00015511272, -0.00037227612) (0.00015416684, -0.00037297763) (0.00015315676, -0.00037358305) (0.0001520922, -0.00037408655) (0.00015098342, -0.00037448328) (0.00014984108, -0.00037476942) (0.00014867621, -0.00037494222) (0.0001475, -0.000375), closed, covered)
  tap_trace_jf_ch3 [copper] = polyline(z=0, xy: (5e-06, -0.001465) (5e-06, -0.00161) (1.5e-05, -0.00161) (1.5e-05, -0.00162) (5e-06, -0.00162) (5e-06, -0.001765) (-5e-06, -0.001765) (-5e-06, -0.001465) (5e-06, -0.001465), closed, covered)
  tap_cut_jf_ch3 = polyline(z=0, xy: (1.1e-05, -0.001465) (1.1e-05, -0.001604) (1.5e-05, -0.001604) (1.5e-05, -0.001626) (1.1e-05, -0.001626) (1.1e-05, -0.001765) (-1.1e-05, -0.001765) (-1.1e-05, -0.001465) (1.1e-05, -0.001465), closed, covered)
  tap_trace_jr_ch3 [copper] = polyline(z=0, xy: (0.000185, -0.00161) (0.000195, -0.00161) (0.000195, -0.001465) (0.000205, -0.001465) (0.000205, -0.001765) (0.000195, -0.001765) (0.000195, -0.00162) (0.000185, -0.00162) (0.000185, -0.00161), closed, covered)
  tap_cut_jr_ch3 = polyline(z=0, xy: (0.000185, -0.001604) (0.000189, -0.001604) (0.000189, -0.001465) (0.000211, -0.001465) (0.000211, -0.001765) (0.000189, -0.001765) (0.000189, -0.001626) (0.000185, -0.001626) (0.000185, -0.001604), closed, covered)
  head_a_cj_ch3 [copper] = polyline(z=0, xy: (4.7e-05, -0.0016475) (4.6803966e-05, -0.0016474904) (4.6609819e-05, -0.0016474616) (4.6419431e-05, -0.0016474139) (4.6234633e-05, -0.0016473478) (4.6057207e-05, -0.0016472638) (4.588886e-05, -0.0016471629) (4.5731213e-05, -0.001647046) (4.5585786e-05, -0.0016469142) (4.5453979e-05, -0.0016467688) (4.5337061e-05, -0.0016466111) (4.5236157e-05, -0.0016464428) (4.5152241e-05, -0.0016462654) (4.5086119e-05, -0.0016460806) (4.5038429e-05, -0.0016458902) (4.5009631e-05, -0.001645696) (4.5e-05, -0.0016455) (4.5e-05, -0.0015845) (4.5009631e-05, -0.001584304) (4.5038429e-05, -0.0015841098) (4.5086119e-05, -0.0015839194) (4.5152241e-05, -0.0015837346) (4.5236157e-05, -0.0015835572) (4.5337061e-05, -0.0015833889) (4.5453979e-05, -0.0015832312) (4.5585786e-05, -0.0015830858) (4.5731213e-05, -0.001582954) (4.588886e-05, -0.0015828371) (4.6057207e-05, -0.0015827362) (4.6234633e-05, -0.0015826522) (4.6419431e-05, -0.0015825861) (4.6609819e-05, -0.0015825384) (4.6803966e-05, -0.0015825096) (4.7e-05, -0.0015825) (6.8e-05, -0.0015825) (6.8196034e-05, -0.0015825096) (6.8390181e-05, -0.0015825384) (6.8580569e-05, -0.0015825861) (6.8765367e-05, -0.0015826522) (6.8942793e-05, -0.0015827362) (6.911114e-05, -0.0015828371) (6.9268787e-05, -0.001582954) (6.9414214e-05, -0.0015830858) (6.9546021e-05, -0.0015832312) (6.9662939e-05, -0.0015833889) (6.9763843e-05, -0.0015835572) (6.9847759e-05, -0.0015837346) (6.9913881e-05, -0.0015839194) (6.9961571e-05, -0.0015841098) (6.9990369e-05, -0.001584304) (7e-05, -0.0015845) (7e-05, -0.0016455) (6.9990369e-05, -0.001645696) (6.9961571e-05, -0.0016458902) (6.9913881e-05, -0.0016460806) (6.9847759e-05, -0.0016462654) (6.9763843e-05, -0.0016464428) (6.9662939e-05, -0.0016466111) (6.9546021e-05, -0.0016467688) (6.9414214e-05, -0.0016469142) (6.9268787e-05, -0.001647046) (6.911114e-05, -0.0016471629) (6.8942793e-05, -0.0016472638) (6.8765367e-05, -0.0016473478) (6.8580569e-05, -0.0016474139) (6.8390181e-05, -0.0016474616) (6.8196034e-05, -0.0016474904) (6.8e-05, -0.0016475) (4.7e-05, -0.0016475), closed, covered)
  head_b_cj_ch3 [copper] = polyline(z=0, xy: (0.000132, -0.0016475) (0.00013180397, -0.0016474904) (0.00013160982, -0.0016474616) (0.00013141943, -0.0016474139) (0.00013123463, -0.0016473478) (0.00013105721, -0.0016472638) (0.00013088886, -0.0016471629) (0.00013073121, -0.001647046) (0.00013058579, -0.0016469142) (0.00013045398, -0.0016467688) (0.00013033706, -0.0016466111) (0.00013023616, -0.0016464428) (0.00013015224, -0.0016462654) (0.00013008612, -0.0016460806) (0.00013003843, -0.0016458902) (0.00013000963, -0.001645696) (0.00013, -0.0016455) (0.00013, -0.0015845) (0.00013000963, -0.001584304) (0.00013003843, -0.0015841098) (0.00013008612, -0.0015839194) (0.00013015224, -0.0015837346) (0.00013023616, -0.0015835572) (0.00013033706, -0.0015833889) (0.00013045398, -0.0015832312) (0.00013058579, -0.0015830858) (0.00013073121, -0.001582954) (0.00013088886, -0.0015828371) (0.00013105721, -0.0015827362) (0.00013123463, -0.0015826522) (0.00013141943, -0.0015825861) (0.00013160982, -0.0015825384) (0.00013180397, -0.0015825096) (0.000132, -0.0015825) (0.000153, -0.0015825) (0.00015319603, -0.0015825096) (0.00015339018, -0.0015825384) (0.00015358057, -0.0015825861) (0.00015376537, -0.0015826522) (0.00015394279, -0.0015827362) (0.00015411114, -0.0015828371) (0.00015426879, -0.001582954) (0.00015441421, -0.0015830858) (0.00015454602, -0.0015832312) (0.00015466294, -0.0015833889) (0.00015476384, -0.0015835572) (0.00015484776, -0.0015837346) (0.00015491388, -0.0015839194) (0.00015496157, -0.0015841098) (0.00015499037, -0.001584304) (0.000155, -0.0015845) (0.000155, -0.0016455) (0.00015499037, -0.001645696) (0.00015496157, -0.0016458902) (0.00015491388, -0.0016460806) (0.00015484776, -0.0016462654) (0.00015476384, -0.0016464428) (0.00015466294, -0.0016466111) (0.00015454602, -0.0016467688) (0.00015441421, -0.0016469142) (0.00015426879, -0.001647046) (0.00015411114, -0.0016471629) (0.00015394279, -0.0016472638) (0.00015376537, -0.0016473478) (0.00015358057, -0.0016474139) (0.00015339018, -0.0016474616) (0.00015319603, -0.0016474904) (0.000153, -0.0016475) (0.000132, -0.0016475), closed, covered)
  pocket_cj_ch3 = polyline(z=0, xy: (3.1e-05, -0.0016635) (3.0803966e-05, -0.0016634904) (3.0609819e-05, -0.0016634616) (3.0419431e-05, -0.0016634139) (3.0234633e-05, -0.0016633478) (3.0057207e-05, -0.0016632638) (2.988886e-05, -0.0016631629) (2.9731213e-05, -0.001663046) (2.9585786e-05, -0.0016629142) (2.9453979e-05, -0.0016627688) (2.9337061e-05, -0.0016626111) (2.9236157e-05, -0.0016624428) (2.9152241e-05, -0.0016622654) (2.9086119e-05, -0.0016620806) (2.9038429e-05, -0.0016618902) (2.9009631e-05, -0.001661696) (2.9e-05, -0.0016615) (2.9e-05, -0.0015685) (2.9009631e-05, -0.001568304) (2.9038429e-05, -0.0015681098) (2.9086119e-05, -0.0015679194) (2.9152241e-05, -0.0015677346) (2.9236157e-05, -0.0015675572) (2.9337061e-05, -0.0015673889) (2.9453979e-05, -0.0015672312) (2.9585786e-05, -0.0015670858) (2.9731213e-05, -0.001566954) (2.988886e-05, -0.0015668371) (3.0057207e-05, -0.0015667362) (3.0234633e-05, -0.0015666522) (3.0419431e-05, -0.0015665861) (3.0609819e-05, -0.0015665384) (3.0803966e-05, -0.0015665096) (3.1e-05, -0.0015665) (0.000169, -0.0015665) (0.00016919603, -0.0015665096) (0.00016939018, -0.0015665384) (0.00016958057, -0.0015665861) (0.00016976537, -0.0015666522) (0.00016994279, -0.0015667362) (0.00017011114, -0.0015668371) (0.00017026879, -0.001566954) (0.00017041421, -0.0015670858) (0.00017054602, -0.0015672312) (0.00017066294, -0.0015673889) (0.00017076384, -0.0015675572) (0.00017084776, -0.0015677346) (0.00017091388, -0.0015679194) (0.00017096157, -0.0015681098) (0.00017099037, -0.001568304) (0.000171, -0.0015685) (0.000171, -0.0016615) (0.00017099037, -0.001661696) (0.00017096157, -0.0016618902) (0.00017091388, -0.0016620806) (0.00017084776, -0.0016622654) (0.00017076384, -0.0016624428) (0.00017066294, -0.0016626111) (0.00017054602, -0.0016627688) (0.00017041421, -0.0016629142) (0.00017026879, -0.001663046) (0.00017011114, -0.0016631629) (0.00016994279, -0.0016632638) (0.00016976537, -0.0016633478) (0.00016958057, -0.0016634139) (0.00016939018, -0.0016634616) (0.00016919603, -0.0016634904) (0.000169, -0.0016635) (3.1e-05, -0.0016635), closed, covered)
  endcap_filt_ch3_start = rectangle(corner=(-0.000311, -0.000915, 0), x_size=2.2e-05, y_size=6e-06)
  endcap_res_ch3_start = rectangle(corner=(0.000539, -0.00255834, 0), x_size=2.2e-05, y_size=6e-06)
  endcap_res_a_ch3_start = rectangle(corner=(0.000189, -0.002921, 0), x_size=2.2e-05, y_size=6e-06)
  ground_main_plane [copper] = rectangle(corner=(-0.0017985, -0.003115, 0), x_size=0.003597, y_size=0.0034915)
  main [silicon] = box(corner=(-0.0017985, -0.003115, -0.000525), size=(0.003597, 0.0034915, 0.000525))
  ground_main_plane.subtract(pocket_LPPin, tap_cut_jr_ch3, cut_stub_f_ch3, cut_feed_in, lead_b_sub_cp_ch3, pocket_LPPout, cut_res_a_ch3, cut_stub_r_ch3, cut_feed_jf_ch3, lead_a_sub_cj_ch3, cut_stub_p_ch3, endcap_filt_ch3_start, endcap_res_ch3_start, tap_cut_n0_ch3, lead_a_sub_cp_ch3, cut_filt_ch3, tap_cut_jf_ch3, pocket_cp_ch3, cut_feed_out, lead_b_sub_cj_ch3, pocket_cj_ch3, endcap_res_a_ch3_start, cut_res_ch3)
boundaries and excitations:
  ThinCond1: ThinConductor Objects=[lead_a_cp_ch3, lead_b_cp_ch3, trace_stub_p_ch3, trace_feed_jf_ch3, lead_a_cj_ch3, lead_b_cj_ch3, trace_stub_f_ch3, trace_stub_r_ch3, trace_res_a_ch3, trace_filt_ch3, trace_res_ch3, trace_feed_in, trace_feed_out, launch_pad_LPPin, launch_pad_LPPout, tap_trace_n0_ch3, plate_cp_ch3, frame_cp_ch3, tap_trace_jf_ch3, tap_trace_jr_ch3, head_a_cj_ch3, head_b_cj_ch3, ground_main_plane] Material=pec Thickness=200nm
  frame_cp_ch3: SignalNet Objects=[lead_a_cp_ch3, trace_feed_jf_ch3, lead_a_cj_ch3, trace_stub_f_ch3, trace_filt_ch3, frame_cp_ch3, tap_trace_jf_ch3, head_a_cj_ch3]
  launch_pad_LPPin: SignalNet Objects=[lead_b_cp_ch3, trace_stub_p_ch3, trace_feed_in, trace_feed_out, launch_pad_LPPin, launch_pad_LPPout, tap_trace_n0_ch3, plate_cp_ch3]
  head_b_cj_ch3: SignalNet Objects=[lead_b_cj_ch3, trace_stub_r_ch3, trace_res_a_ch3, trace_res_ch3, tap_trace_jr_ch3, head_b_cj_ch3]
  g_wb: SignalNet Objects=[g_wb, g_wb_1..g_wb_17, ground_main_plane]
setups:
  Setup: Matrix AdaptiveFreq=6.7GHz Cap{MaxPass=15 MinPass=2 MinConvPass=2 PerError=0.3 PerRefine=30 AutoIncreaseSolutionOrder SolutionOrder=Normal Solver_Type=Iterative}
source amplitudes:
  frame_cp_ch3: Cap 1V 0deg
  g_wb, head_b_cj_ch3, launch_pad_LPPin: Cap 0V 0deg

design q3d6_full_2114_q3d (Q3D Extractor, model units mm)
options: SParamCalcMethod=EqTransLine Calculate_Lossy_Dielectrics
geometry:
  lead_a_cp_ch3_path = polyline((0, -0.000362999, 0) (0, -0.000415, 0))
  lead_a_cp_ch3 [copper] = polyline((5e-06, -0.000362999, 0) (-5e-06, -0.000362999, 0))
  lead_a_cp_ch3.sweep_along_path(lead_a_cp_ch3_path)
  lead_a_sub_cp_ch3_path = polyline((0, -0.000362999, 0) (0, -0.000415, 0))
  lead_a_sub_cp_ch3 = polyline((1.1e-05, -0.000362999, 0) (-1.1e-05, -0.000362999, 0))
  lead_a_sub_cp_ch3.sweep_along_path(lead_a_sub_cp_ch3_path)
  lead_b_cp_ch3_path = polyline((0, -0.000262001, 0) (0, -0.00015, 0))
  lead_b_cp_ch3 [copper] = polyline((-5e-06, -0.000262001, 0) (5e-06, -0.000262001, 0))
  lead_b_cp_ch3.sweep_along_path(lead_b_cp_ch3_path)
  lead_b_sub_cp_ch3_path = polyline((0, -0.000262001, 0) (0, -0.00015, 0))
  lead_b_sub_cp_ch3 = polyline((-1.1e-05, -0.000262001, 0) (1.1e-05, -0.000262001, 0))
  lead_b_sub_cp_ch3.sweep_along_path(lead_b_sub_cp_ch3_path)
  trace_stub_p_ch3_path = polyline((0, -0.0001, 0) (0, -0.00015, 0))
  trace_stub_p_ch3 [copper] = polyline((5e-06, -0.0001, 0) (-5e-06, -0.0001, 0))
  trace_stub_p_ch3.sweep_along_path(trace_stub_p_ch3_path)
  cut_stub_p_ch3_path = polyline((0, -0.0001, 0) (0, -0.00015, 0))
  cut_stub_p_ch3 = polyline((1.1e-05, -0.0001, 0) (-1.1e-05, -0.0001, 0))
  cut_stub_p_ch3.sweep_along_path(cut_stub_p_ch3_path)
  trace_feed_jf_ch3_path = polyline((0, -0.000415, 0) (0, -0.001465, 0))
  trace_feed_jf_ch3 [copper] = polyline((5e-06, -0.000415, 0) (-5e-06, -0.000415, 0))
  trace_feed_jf_ch3.sweep_along_path(trace_feed_jf_ch3_path)
  cut_feed_jf_ch3_path = polyline((0, -0.000415, 0) (0, -0.001465, 0))
  cut_feed_jf_ch3 = polyline((1.1e-05, -0.000415, 0) (-1.1e-05, -0.000415, 0))
  cut_feed_jf_ch3.sweep_along_path(cut_feed_jf_ch3_path)
  lead_a_cj_ch3_path = polyline((5.5001e-05, -0.001615, 0) (4.5e-05, -0.001615, 0))
  lead_a_cj_ch3 [copper] = polyline((5.5001e-05, -0.00162, 0) (5.5001e-05, -0.00161, 0))
  lead_a_cj_ch3.sweep_along_path(lead_a_cj_ch3_path)
  lead_a_sub_cj_ch3_path = polyline((5.5001e-05, -0.001615, 0) (4.5e-05, -0.001615, 0))
  lead_a_sub_cj_ch3 = polyline((5.5001e-05, -0.001626, 0) (5.5001e-05, -0.001604, 0))
  lead_a_sub_cj_ch3.sweep_along_path(lead_a_sub_cj_ch3_path)
  lead_b_cj_ch3_path = polyline((0.000144999, -0.001615, 0) (0.000155, -0.001615, 0))
  lead_b_cj_ch3 [copper] = polyline((0.000144999, -0.00161, 0) (0.000144999, -0.00162, 0))
  lead_b_cj_ch3.sweep_along_path(lead_b_cj_ch3_path)
  lead_b_sub_cj_ch3_path = polyline((0.000144999, -0.001615, 0) (0.000155, -0.001615, 0))
  lead_b_sub_cj_ch3 = polyline((0.000144999, -0.001604, 0) (0.000144999, -0.001626, 0))
  lead_b_sub_cj_ch3.sweep_along_path(lead_b_sub_cj_ch3_path)
  trace_stub_f_ch3_path = polyline((2.5e-05, -0.001615, 0) (4.5e-05, -0.001615, 0))
  trace_stub_f_ch3 [copper] = polyline((2.5e-05, -0.00161, 0) (2.5e-05, -0.00162, 0))
  trace_stub_f_ch3.sweep_along_path(trace_stub_f_ch3_path)
  cut_stub_f_ch3_path = polyline((2.5e-05, -0.001615, 0) (4.5e-05, -0.001615, 0))
  cut_stub_f_ch3 = polyline((2.5e-05, -0.001604, 0) (2.5e-05, -0.001626, 0))
  cut_stub_f_ch3.sweep_along_path(cut_stub_f_ch3_path)
  trace_stub_r_ch3_path = polyline((0.000175, -0.001615, 0) (0.000155, -0.001615, 0))
  trace_stub_r_ch3 [copper] = polyline((0.000175, -0.00162, 0) (0.000175, -0.00161, 0))
  trace_stub_r_ch3.sweep_along_path(trace_stub_r_ch3_path)
  cut_stub_r_ch3_path = polyline((0.000175, -0.001615, 0) (0.000155, -0.001615, 0))
  cut_stub_r_ch3 = polyline((0.000175, -0.001626, 0) (0.000175, -0.001604, 0))
  cut_stub_r_ch3.sweep_along_path(cut_stub_r_ch3_path)
  trace_res_a_ch3_path = polyline((0.0002, -0.002915, 0) (0.0002, -0.001765, 0))
  trace_res_a_ch3 [copper] = polyline((0.000195, -0.002915, 0) (0.000205, -0.002915, 0))
  trace_res_a_ch3.sweep_along_path(trace_res_a_ch3_path)
  cut_res_a_ch3_path = polyline((0.0002, -0.002915, 0) (0.0002, -0.001765, 0))
  cut_res_a_ch3 = polyline((0.000189, -0.002915, 0) (0.000211, -0.002915, 0))
  cut_res_a_ch3.sweep_along_path(cut_res_a_ch3_path)
  trace_filt_ch3_path = polyline(z=0, xy: (-0.0003, -0.000915) (-0.0003, -0.0022822498) (0, -0.0022822498) (0, -0.001765))
  trace_filt_ch3_path.fillet(Vertices=trace_filt_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  trace_filt_ch3 [copper] = polyline((-0.000295, -0.000915, 0) (-0.000305, -0.000915, 0))
  trace_filt_ch3.sweep_along_path(trace_filt_ch3_path)
  cut_filt_ch3_path = polyline(z=0, xy: (-0.0003, -0.000915) (-0.0003, -0.0022822498) (0, -0.0022822498) (0, -0.001765))
  cut_filt_ch3_path.fillet(Vertices=cut_filt_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  cut_filt_ch3 = polyline((-0.000289, -0.000915, 0) (-0.000311, -0.000915, 0))
  cut_filt_ch3.sweep_along_path(cut_filt_ch3_path)
  trace_res_ch3_path = polyline(z=0, xy: (0.00055, -0.00255234) (0.00055, -0.000665) (0.0002, -0.000665) (0.0002, -0.001465))
  trace_res_ch3_path.fillet(Vertices=trace_res_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  trace_res_ch3 [copper] = polyline((0.000545, -0.00255234, 0) (0.000555, -0.00255234, 0))
  trace_res_ch3.sweep_along_path(trace_res_ch3_path)
  cut_res_ch3_path = polyline(z=0, xy: (0.00055, -0.00255234) (0.00055, -0.000665) (0.0002, -0.000665) (0.0002, -0.001465))
  cut_res_ch3_path.fillet(Vertices=cut_res_ch3_path.vertex(2 of 4, 3 of 4) Radius=9.9e-05 Setback=0mm)
  cut_res_ch3 = polyline((0.000539, -0.00255234, 0) (0.000561, -0.00255234, 0))
  cut_res_ch3.sweep_along_path(cut_res_ch3_path)
  trace_feed_in_path = polyline((-0.00117, 0, 0) (-0.00015, 0, 0))
  trace_feed_in [copper] = polyline((-0.00117, 5e-06, 0) (-0.00117, -5e-06, 0))
  trace_feed_in.sweep_along_path(trace_feed_in_path)
  cut_feed_in_path = polyline((-0.00117, 0, 0) (-0.00015, 0, 0))
  cut_feed_in = polyline((-0.00117, 1.1e-05, 0) (-0.00117, -1.1e-05, 0))
  cut_feed_in.sweep_along_path(cut_feed_in_path)
  trace_feed_out_path = polyline((0.00015, 0, 0) (0.00117, 0, 0))
  trace_feed_out [copper] = polyline((0.00015, 5e-06, 0) (0.00015, -5e-06, 0))
  trace_feed_out.sweep_along_path(trace_feed_out_path)
  cut_feed_out_path = polyline((0.00015, 0, 0) (0.00117, 0, 0))
  cut_feed_out = polyline((0.00015, 1.1e-05, 0) (0.00015, -1.1e-05, 0))
  cut_feed_out.sweep_along_path(cut_feed_out_path)
  g_wb [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-5.5e-05 YPadPos=-0.000765 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_1 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-5.5e-05 YPadPos=-0.001115 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_2 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000255 YPadPos=-0.0025316667 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_3 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000255 YPadPos=-0.0021483333 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_4 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0012568124 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_5 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0015986249 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_6 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.000355 YPadPos=-0.0019404373 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_7 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=5.5e-05 YPadPos=-0.0020236249 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_8 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.002174872 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_9 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001797404 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_10 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001419936 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_11 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000605 YPadPos=-0.001042468 ZPadPos=0 XDir=-1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_12 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000145 YPadPos=-0.00093166667 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_13 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.000145 YPadPos=-0.0011983333 ZPadPos=0 XDir=1 YDir=0 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_14 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00083 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_15 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=-0.00049 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_16 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00049 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  g_wb_17 [pec] = bondwire(WireType=LOW WireDiameter=0.015mm NumSides=6 XPadPos=0.00083 YPadPos=-5.5e-05 ZPadPos=0 XDir=0 YDir=1 ZDir=0 Distance=0.00011 h1=0.00011 h2=0mm alpha=80deg beta=80deg WhichAxis=Z)
  launch_pad_LPPin [copper] = polyline(z=0, xy: (-0.0012, 5e-06) (-0.001322, 0.0001) (-0.001522, 0.0001) (-0.001522, -0.0001) (-0.001322, -0.0001) (-0.0012, -5e-06) (-0.00117, -5e-06) (-0.00117, 5e-06) (-0.0012, 5e-06), closed, covered)
  pocket_LPPin = polyline(z=0, xy: (-0.0012, 1.1e-05) (-0.001322, 0.0001765) (-0.0015985, 0.0001765) (-0.0015985, -0.0001765) (-0.001322, -0.0001765) (-0.0012, -1.1e-05) (-0.00117, -1.1e-05) (-0.00117, 1.1e-05) (-0.0012, 1.1e-05), closed, covered)
  launch_pad_LPPout [copper] = polyline(z=0, xy: (0.0012, -5e-06) (0.001322, -0.0001) (0.001522, -0.0001) (0.001522, 0.0001) (0.001322, 0.0001) (0.0012, 5e-06) (0.00117, 5e-06) (0.00117, -5e-06) (0.0012, -5e-06), closed, covered)
  pocket_LPPout = polyline(z=0, xy: (0.0012, -1.1e-05) (0.001322, -0.0001765) (0.0015985, -0.0001765) (0.0015985, 0.0001765) (0.001322, 0.0001765) (0.0012, 1.1e-05) (0.00117, 1.1e-05) (0.00117, -1.1e-05) (0.0012, -1.1e-05), closed, covered)
  tap_trace_n0_ch3 [copper] = polyline(z=0, xy: (-5e-06, -0.0001) (-5e-06, -5e-06) (-0.00015, -5e-06) (-0.00015, 5e-06) (0.00015, 5e-06) (0.00015, -5e-06) (5e-06, -5e-06) (5e-06, -0.0001) (-5e-06, -0.0001), closed, covered)
  tap_cut_n0_ch3 = polyline(z=0, xy: (-1.1e-05, -0.0001) (-1.1e-05, -1.1e-05) (-0.00015, -1.1e-05) (-0.00015, 1.1e-05) (0.00015, 1.1e-05) (0.00015, -1.1e-05) (1.1e-05, -1.1e-05) (1.1e-05, -0.0001) (-1.1e-05, -0.0001), closed, covered)
  plate_cp_ch3 [copper] = polyline(z=0, xy: (8.25e-05, -0.000295) (8.2461478e-05, -0.00029578414) (8.2346282e-05, -0.00029656072) (8.2155523e-05, -0.00029732228) (8.1891036e-05, -0.00029806147) (8.155537e-05, -0.00029877117) (8.1151757e-05, -0.00029944456) (8.0684084e-05, -0.00030007515) (8.0156854e-05, -0.00030065685) (7.9575146e-05, -0.00030118408) (7.8944562e-05, -0.00030165176) (7.8271174e-05, -0.00030205537) (7.7561467e-05, -0.00030239104) (7.6822277e-05, -0.00030265552) (7.6060723e-05, -0.00030284628) (7.5284137e-05, -0.00030296148) (7.45e-05, -0.000303) (-7.45e-05, -0.000303) (-7.5284137e-05, -0.00030296148) (-7.6060723e-05, -0.00030284628) (-7.6822277e-05, -0.00030265552) (-7.7561467e-05, -0.00030239104) (-7.8271174e-05, -0.00030205537) (-7.8944562e-05, -0.00030165176) (-7.9575146e-05, -0.00030118408) (-8.0156854e-05, -0.00030065685) (-8.0684084e-05, -0.00030007515) (-8.1151757e-05, -0.00029944456) (-8.155537e-05, -0.00029877117) (-8.1891036e-05, -0.00029806147) (-8.2155523e-05, -0.00029732228) (-8.2346282e-05, -0.00029656072) (-8.2461478e-05, -0.00029578414) (-8.25e-05, -0.000295) (-8.25e-05, -0.00027) (-8.2461478e-05, -0.00026921586) (-8.2346282e-05, -0.00026843928) (-8.2155523e-05, -0.00026767772) (-8.1891036e-05, -0.00026693853) (-8.155537e-05, -0.00026622883) (-8.1151757e-05, -0.00026555544) (-8.0684084e-05, -0.00026492485) (-8.0156854e-05, -0.00026434315) (-7.9575146e-05, -0.00026381592) (-7.8944562e-05, -0.00026334824) (-7.8271174e-05, -0.00026294463) (-7.7561467e-05, -0.00026260896) (-7.6822277e-05, -0.00026234448) (-7.6060723e-05, -0.00026215372) (-7.5284137e-05, -0.00026203852) (-7.45e-05, -0.000262) (7.45e-05, -0.000262) (7.5284137e-05, -0.00026203852) (7.6060723e-05, -0.00026215372) (7.6822277e-05, -0.00026234448) (7.7561467e-05, -0.00026260896) (7.8271174e-05, -0.00026294463) (7.8944562e-05, -0.00026334824) (7.9575146e-05, -0.00026381592) (8.0156854e-05, -0.00026434315) (8.0684084e-05, -0.00026492485) (8.1151757e-05, -0.00026555544) (8.155537e-05, -0.00026622883) (8.1891036e-05, -0.00026693853) (8.2155523e-05, -0.00026767772) (8.2346282e-05, -0.00026843928) (8.2461478e-05, -0.00026921586) (8.25e-05, -0.00027) (8.25e-05, -0.000295), closed, covered)
  frame_cp_ch3 [copper] = polyline(z=0, xy: (8.25e-05, -0.000311) (8.3284137e-05, -0.00031096148) (8.4060723e-05, -0.00031084628) (8.4822277e-05, -0.00031065552) (8.5561467e-05, -0.00031039104) (8.6271174e-05, -0.00031005537) (8.6944562e-05, -0.00030965176) (8.7575146e-05, -0.00030918408) (8.8156854e-05, -0.00030865685) (8.8684084e-05, -0.00030807515) (8.9151757e-05, -0.00030744456) (8.955537e-05, -0.00030677117) (8.9891036e-05, -0.00030606147) (9.0155523e-05, -0.00030532228) (9.0346282e-05, -0.00030456072) (9.0461478e-05, -0.00030378414) (9.05e-05, -0.000303) (9.05e-05, -0.000262) (9.0461478e-05, -0.00026121586) (9.0346282e-05, -0.00026043928) (9.0155523e-05, -0.00025967772) (8.9891036e-05, -0.00025893853) (8.955537e-05, -0.00025822883) (8.9151757e-05, -0.00025755544) (8.8684084e-05, -0.00025692485) (8.8156854e-05, -0.00025634315) (8.7575146e-05, -0.00025581592) (8.6944562e-05, -0.00025534824) (8.6271174e-05, -0.00025494463) (8.5561467e-05, -0.00025460896) (8.4822277e-05, -0.00025434448) (8.4060723e-05, -0.00025415372) (8.3284137e-05, -0.00025403852) (8.25e-05, -0.000254) (1.909818e-05, -0.000254) (1.8901939e-05, -0.00025399518) (1.8412015e-05, -0.00025397111) (1.80216e-05, -0.00025393266) (1.7633541e-05, -0.0002538751) (1.7248774e-05, -0.00025379856) (1.6868226e-05, -0.00025370324) (1.6492814e-05, -0.00025358936) (1.6123441e-05, -0.0002534572) (1.5760999e-05, -0.00025330707) (1.540636e-05, -0.00025313934) (1.5060378e-05, -0.00025295441) (1.4723887e-05, -0.00025275272) (1.4397697e-05, -0.00025253477) (1.4082595e-05, -0.00025230107) (1.3779339e-05, -0.0002520522) (1.348866e-05, -0.00025178874) (1.3211259e-05, -0.00025151134) (1.2947803e-05, -0.00025122066) (1.2698928e-05, -0.0002509174) (1.2465232e-05, -0.0002506023) (1.2247279e-05, -0.00025027611) (1.2045594e-05, -0.00024993962) (1.1860663e-05, -0.00024959364) (1.1692931e-05, -0.000249239) (1.1542802e-05, -0.00024887656) (1.1410639e-05, -0.00024850719) (1.1296759e-05, -0.00024813177) (1.1201436e-05, -0.00024775123) (1.1124902e-05, -0.00024736646) (1.1067338e-05, -0.0002469784) (1.1028886e-05, -0.00024658799) (1.1004817e-05, -0.00024609806) (1.1e-05, -0.000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